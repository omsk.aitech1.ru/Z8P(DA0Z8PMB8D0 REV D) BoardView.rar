# Allegro board Quanta Z8P DA0Z8PMB8D0 REV D - BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_B_BS#1: length 95.3
  TOP w0.102: v1(110.51,44.38) 110.91,43.97 111.31,43.97 111.98,44.64 111.98,46.29 112.36,46.66 112.51,46.66 112.78,46.93 112.93,47.97 U11.N8 ; U10.N8 95.02,47.97 94.87,46.93 94.6,46.66 94.45,46.66 94.07,46.29 94.07,44.64 93.4,43.97 93.01,43.97 v1(92.6,44.38)
  TOP w0.152: v1(103.07,44.22) 103.39,44.22 104.51,43.1 R199.2
  IN2 w0.102: v1(92.6,44.38) 93.01,43.97 93.4,43.97 93.77,44.34 96.56,44.34 96.85,44.62 102.66,44.62 v1(103.07,44.22) 103.23,44.38 104.09,44.38 104.19,44.28 104.19,44.06 104.29,43.96 104.49,43.96 104.6,44.06 104.6,44.28 104.7,44.38 104.9,44.38 105,44.28 105,44.06 105.1,43.96 105.31,43.96 105.41,44.06 105.41,44.28 105.51,44.38 105.71,44.38 105.81,44.28 105.81,44.06 105.92,43.96 106.12,43.96 106.22,44.06 106.22,44.28 106.32,44.38 106.53,44.38 106.63,44.28 106.63,44.06 106.73,43.96 106.93,43.96 107.03,44.06 107.03,44.28 107.14,44.38 107.34,44.38 107.44,44.28 107.44,44.06 107.54,43.96 107.75,43.96 107.85,44.06 107.85,44.28 107.95,44.38 108.15,44.38 108.25,44.28 108.25,44.04 108.35,43.93 109.85,43.93 110.29,44.38 v1(110.51,44.38)
  IN3 w0.102: 106.08,69.75 106.08,71.97 103.86,74.19 103.86,74.19 102.8,74.61 102.44,74.61 v1(101.53,74.27)
  IN3 w0.152: v1(103.07,44.22) 103.64,43.64 106.38,43.64 107.82,45.08 107.82,47.91 106.08,49.65 106.08,57.9 105.93,58.06 105.62,58.06 105.49,58.18 105.49,58.54 105.62,58.67 105.93,58.67 106.08,58.82 106.08,69.75
  BOTTOM w0.102: v1(101.53,74.27) 101.26,74.54 101.26,76.2 U21.BG8 ; U27.N8 108.25,48.68 108.13,48.56 108.13,48.36 108.24,48.25 108.58,48.25 108.75,48.42 108.9,48.42 109.03,48.29 109.03,48.14 108.79,47.89 108.79,47.08 109.25,46.61 109.39,46.61 109.61,46.4 109.61,45.68 109.81,45.47 109.81,45.02 110.46,44.38 v1(110.51,44.38) ; v1(92.6,44.38) 92.55,44.38 91.91,45.02 91.91,45.47 91.7,45.68 91.7,46.4 91.48,46.61 91.35,46.61 90.88,47.08 90.88,47.89 91.12,48.14 91.12,48.29 90.99,48.42 90.84,48.42 90.68,48.25 90.34,48.25 90.23,48.36 90.23,48.56 90.35,48.68 U26.N8
M_B_BS#2: length 86.7
  TOP w0.102: v1(92.65,47.63) 92.65,47.98 92.59,48.04 92.28,48.04 92.12,48.19 92.12,48.77 92.04,48.85 91.67,48.85 91.51,49.01 91.51,49.31 U10.M3 ; U11.M3 109.42,49.31 109.42,49.01 109.58,48.85 109.95,48.85 110.03,48.77 110.03,48.19 110.18,48.04 110.5,48.04 110.56,47.98 v1(110.56,47.63)
  IN2 w0.102: v1(92.65,47.63) 92.65,47.33 92.76,47.22 93.31,47.22 93.47,47.06 99.17,47.06 99.29,47.17 99.29,47.73 99.41,47.85 99.58,47.85 99.7,47.73 99.7,47.13 99.81,47.02 100.48,47.02 100.61,47.15 100.61,47.24 100.19,47.66 v1(100.19,47.78) 100.33,47.92 105.87,47.92 106.32,47.47 110.4,47.47 v1(110.56,47.63)
  IN3 w0.152: v1(100.19,47.78) 99.97,47.56 97.65,47.56 97.42,47.34 97.42,43.79 97.3,43.66 96.82,43.66 96.69,43.79 96.69,46.06 96.56,46.19 96.28,46.19 96.15,46.31 96.15,48.37 96.59,48.81 97.78,48.81 98.2,48.39 99.37,48.39 99.78,48.8 99.78,49.28 99.39,49.67 99.39,68.78 96.87,71.3 v1(96.87,71.76)
  BOTTOM w0.089: U21.BH15 98.07,75.87 98.07,75.25 97.85,75.04 97.85,73.6
  BOTTOM w0.102: v1(110.56,47.63) 110.97,48.04 111.36,48.04 111.73,48.4 U27.M3 ; v1(96.87,71.76) 97.85,72.74 97.85,73.6 ; v1(92.65,47.63) 93.06,48.04 93.46,48.04 93.82,48.4 U26.M3
  BOTTOM w0.152: R434.2 v1(98.41,41.94) 98.41,43.73 100.19,45.51 v1(100.19,47.78)
M_B_CAS#: length 85.6
  TOP w0.102: v1(92.65,50.88) 91.98,50.88 91.87,50.99 91.87,51.44 91.73,51.58 91.57,51.58 91.35,51.35 U10.K3 ; U11.K3 109.26,51.35 109.48,51.58 109.64,51.58 109.78,51.44 109.78,50.99 109.89,50.88 v1(110.56,50.88)
  IN1 w0.127: v1(103.2,51.41) 103.64,51.86 103.64,62.07 103.99,62.42 103.99,66.2 104.09,66.31 104.09,66.61 103.97,66.74 103.05,66.74 102.91,66.88 102.91,67.16 103.05,67.3 103.99,67.3 104.12,67.42 104.12,67.73 103.99,67.86 103.05,67.86 102.91,68 102.91,68.27 103.05,68.41 104.81,68.41 104.94,68.54 104.94,68.96 104.81,69.09 103.18,69.09 102.99,69.27 102.99,69.51 103.17,69.69 104.81,69.69 104.94,69.82 104.94,71.41 104.81,71.54 104.49,71.54 104.37,71.41 104.37,70.35 104.24,70.23 103.88,70.23 103.75,70.35 103.75,71.42 103.62,71.55 103.27,71.55 103.14,71.42 103.14,70.51 v1(102.75,70.11)
  IN2 w0.102: v1(92.65,50.88) 93.06,50.47 93.42,50.47 93.45,50.51 96.86,50.51 97.77,51.41 v1(103.2,51.41) 103.4,51.21 103.58,51.21 103.66,51.29 103.66,51.75 103.78,51.87 103.95,51.87 104.07,51.75 104.07,51.31 104.16,51.21 104.37,51.21 104.47,51.31 104.47,51.75 104.59,51.87 104.76,51.87 104.88,51.75 104.88,51.29 104.96,51.21 105.2,51.21 105.28,51.29 105.28,51.75 105.4,51.87 105.57,51.87 105.69,51.75 105.69,51.31 105.79,51.21 106.85,51.21 107.55,50.51 109.96,50.51 110.34,50.88 v1(110.56,50.88)
  BOTTOM w0.089: U21.BH4 103.12,76.08 102.99,75.95 102.99,74.61 103.12,74.48 103.64,73.95
  BOTTOM w0.102: v1(92.65,50.88) 93.06,50.47 93.4,50.47 U26.K3 ; U27.K3 111.31,50.47 110.97,50.47 v1(110.56,50.88) ; 103.64,73.95 104.02,73.58 104.02,71.77 102.75,70.5 v1(102.75,70.11)
  BOTTOM w0.152: R438.2 103.77,40.75 v1(103.77,42.61) 103.77,44.94 103.07,45.64 103.07,51.28 v1(103.2,51.41)
M_B_CKE0: length 81.6
  TOP w0.102: U10.K9 95.49,50.75 94.19,50.75 93.35,50.47 93.06,50.47 v1(92.65,50.07) ; v1(110.56,50.07) 110.97,50.47 111.26,50.47 111.82,50.66 113.21,50.66 U11.K9
  IN2 w0.102: v1(110.56,50.07) 108.84,50.07 108.25,49.47 107.93,49.47 107.7,49.71 107.7,49.79 106.68,50.8 99.45,50.8 v1(98.46,49.82) 98.46,50.72 98.37,50.8 97.78,50.8 97.41,50.43 97.41,50.29 97.49,50.21 97.88,50.21 98,50.09 98,49.89 97.92,49.81 97.6,49.81 97.5,49.7 97.5,49.42 97.39,49.32 97.19,49.32 97.09,49.42 97.09,49.99 96.98,50.1 96.26,50.1 96.16,50 96.16,49.39 96.07,49.3 95.34,49.3 95.24,49.4 95.24,49.97 95.14,50.07 94.93,50.07 94.83,49.97 94.83,49.4 94.73,49.3 94.53,49.3 94.42,49.4 94.42,49.97 94.32,50.07 94.12,50.07 94.02,49.97 94.02,49.4 93.92,49.3 93.82,49.3 93.46,49.66 92.78,49.66 92.65,49.79 v1(92.65,50.07)
  IN3 w0.14: v1(96.87,73.68) 96.43,73.24 96.43,71.18
  IN3 w0.152: 96.43,71.18 98.83,68.78 98.83,50.19 v1(98.46,49.82)
  BOTTOM w0.089: U21.BG18 96.55,76.12 96.55,75.79 96.42,75.66 96.42,74.13 v1(96.87,73.68)
  BOTTOM w0.102: v1(92.65,50.07) 92.65,50.36 92.53,50.48 92.28,50.48 92.14,50.34 91.8,50.34 91.39,50.75 91.14,50.75 90.91,50.52 90.77,50.52 90.55,50.75 90.16,50.75 89.83,51.08 U26.K9 ; v1(110.56,50.07) 110.56,50.36 110.44,50.48 110.19,50.48 110.05,50.34 109.71,50.34 109.3,50.75 109.04,50.75 108.82,50.52 108.68,50.52 108.45,50.75 108.07,50.75 107.74,51.08 U27.K9
  BOTTOM w0.152: R431.2 v1(95.36,40.69) 95.36,42.64 97.9,45.18 97.9,49.26 v1(98.46,49.82)
M_B_CLK0: length 68.3
  TOP w0.102: U11.J7 112.19,51.88 112.12,51.81 112.12,51.65 112.26,51.51 112.26,51.34 111.99,51.08 111.86,51.08 111.25,51.69 v1(111.25,51.69) ; U10.J7 94.14,51.85 94.04,51.85 93.24,52.1 93,52.1 92.69,51.97 v1(92.45,51.72)
  TOP w0.114: v1(102.41,53.22) 102.14,52.95 101.81,52.95 R156.2
  IN2 w0.102: v1(92.45,51.72) 92.83,52.1 93.25,52.1 94.23,51.12 96.33,51.12 98.3,53.09 102.28,53.09 v1(102.41,53.22) 102.55,53.08 103.22,53.08 103.4,53.26 103.4,53.64 103.66,53.9 104.11,53.9 104.37,53.64 104.37,53.26 104.55,53.08 105.62,53.08 106.63,52.07 106.86,52.07 107.82,51.12 109.1,51.12 110.08,52.1 110.84,52.1 v1(111.25,51.69)
  IN3 w0.114: v1(96.78,78.39) 97.05,78.12 97.2,78.12 97.43,77.89 97.43,77.19 97.21,76.98 94.78,76.98 94.58,76.78 94.58,76.5 94.72,76.36 97.76,76.36 99.16,74.96 99.16,74.07 100.44,72.79 100.44,72.4 101.74,71.1 101.74,70.45 103.11,69.08 103.11,55.19 101.94,54.01 101.94,53.02 102.03,52.92 102.11,52.92 v1(102.41,53.22)
  BOTTOM w0.102: U27.J7 109.36,51.77 109.56,51.77 110.35,52.1 110.84,52.1 v1(111.25,51.69) ; U26.J7 91.59,51.88 91.68,51.79 91.68,51.11 91.79,51 91.91,51 92.45,51.54 v1(92.45,51.72)
  BOTTOM w0.14: U21.BD19 96.49,78.1 v1(96.78,78.39)
M_B_CLK0#: length 68.3
  TOP w0.102: U10.K7 94.32,51.08 94.21,51.19 94.21,51.31 94.38,51.48 94.38,51.58 94.32,51.64 94.01,51.64 93.34,51.86 93.25,51.86 v1(93.08,51.69) ; v1(110.61,51.69) 110.67,51.69 111.08,51.29 111.36,51.29 111.77,50.87 112.07,50.87 112.28,51.08 U11.K7
  TOP w0.114: v1(102.41,52.44) 102.2,52.65 101.84,52.65 R156.1
  IN2 w0.102: v1(110.61,51.69) 110.61,51.84 110.55,51.9 110.16,51.9 110.05,51.79 110.05,51.69 110.16,51.59 110.16,51.42 109.95,51.21 109.81,51.21 109.7,51.32 109.59,51.32 109.18,50.92 107.73,50.92 106.78,51.87 106.54,51.87 105.54,52.88 104.47,52.88 104.16,53.18 104.16,53.55 104.02,53.69 103.74,53.69 103.61,53.55 103.61,53.18 103.3,52.88 102.68,52.88 102.41,52.61 v1(102.41,52.44) 101.97,52.89 98.39,52.89 96.42,50.92 94.15,50.92 93.63,51.44 93.43,51.44 93.28,51.29 92.87,51.29 92.82,51.34 92.82,51.56 92.96,51.69 v1(93.08,51.69)
  IN3 w0.114: v1(102.41,52.44) 102.15,52.71 101.94,52.71 101.72,52.93 101.72,54.1 102.89,55.28 102.89,68.99 101.52,70.36 101.52,71.01 100.23,72.31 100.23,72.7 98.94,73.98 98.94,74.87 97.67,76.14 94.63,76.14 94.36,76.41 94.36,76.87 94.69,77.19 97.12,77.19 97.21,77.28 97.21,77.81 97.13,77.88 96.91,77.88 v1(96.74,77.71)
  BOTTOM w0.102: v1(110.61,51.69) 110.61,51.82 110.54,51.9 110.39,51.9 109.87,51.68 109.6,51.57 109.54,51.51 109.54,51.33 109.64,51.23 109.64,51.09 109.51,50.96 109.38,50.96 U27.K7 ; v1(93.08,51.69) 93.08,51.61 92.76,51.29 92.48,51.29 92,50.8 91.63,50.8 U26.K7
  BOTTOM w0.14: U21.BE19 96.61,77.71 v1(96.74,77.71)
M_B_CS#0: length 81.8
  TOP w0.102: v1(93.29,48.44) 92.88,48.85 92.33,48.85 91.82,49.36 91.61,49.69 91.49,49.81 U10.L2 ; v1(111.19,48.44) 110.79,48.85 110.23,48.85 109.72,49.36 109.52,49.69 109.39,49.81 U11.L2
  IN2 w0.102: v1(111.19,48.44) 110.79,48.85 106.83,48.85 106.49,49.19 99.36,49.19 v1(99.22,49.05) 98.82,48.65 98.24,48.65 98.13,48.54 98.13,48.35 98.01,48.23 97.84,48.23 97.72,48.35 97.72,48.54 97.61,48.65 97.15,48.65 97.05,48.54 97.05,48.39 96.95,48.28 96.75,48.28 96.65,48.39 96.65,48.54 96.54,48.65 96.34,48.65 96.24,48.54 96.24,47.79 96.12,47.67 95.95,47.67 95.83,47.79 95.83,48.54 95.73,48.65 95.53,48.65 95.43,48.54 95.43,47.79 95.31,47.67 95.14,47.67 95.02,47.79 95.02,48.54 94.92,48.65 94.72,48.65 94.61,48.54 94.61,47.79 94.5,47.67 94.33,47.67 94.21,47.79 94.21,48.54 94.11,48.65 93.49,48.65 v1(93.29,48.44)
  IN3 w0.152: v1(96.87,74.31) 96.16,73.61 96.16,70.97 98.5,68.63 98.5,50.66 98,50.16 98,49.38 98.32,49.05 v1(99.22,49.05)
  BOTTOM w0.089: 97.39,77 97.35,76.96 97.07,76.96 96.87,76.76 96.87,76.52 96.99,76.4 96.99,76.15 96.85,76 96.85,75.76 97.02,75.58 97.02,75.38 97.27,75.14 97.27,74.71 v1(96.87,74.31)
  BOTTOM w0.102: v1(93.29,48.44) 93.29,48.68 93.69,49.09 93.69,49.41 94.09,49.81 94.43,49.81 94.56,49.93 94.74,49.93 94.91,49.76 95.12,49.76 95.35,49.99 U26.L2 ; v1(111.19,48.44) 111.19,48.68 111.6,49.09 111.6,49.41 112,49.81 112.34,49.81 112.46,49.93 112.64,49.93 112.82,49.76 113.03,49.76 113.26,49.99 U27.L2 ; U21.BD17 97.2,77.88 97.51,77.58 97.51,77.12 97.39,77
  BOTTOM w0.152: v1(99.22,49.05) 98.25,48.08 98.25,44.92 96.38,43.05 v1(96.38,42.23) R432.2
M_B_DQ0: length 31.1
  IN3 w0.102: v1(94.12,54.65) 93.94,54.65 93.57,55.02 92.54,55.02 92.4,54.88 92.4,54.33 92.23,54.15 89.35,54.15 88.45,55.05
  IN3 w0.127: v1(91.92,70.12) 91.92,68.44 91.77,68.3 91.77,62.55 88.3,59.07 88.3,55.2 88.45,55.05
  BOTTOM w0.089: 93.51,71.04 93.51,71.17 93.38,71.3 93,71.3 92.87,71.43 92.87,75.37 U21.BJ26
  BOTTOM w0.102: v1(91.92,70.12) 92.63,70.83 93.35,70.83 93.51,71 93.51,71.04
  BOTTOM w0.14: v1(94.12,54.65) U26.E3
M_B_DQ1: length 34.6
  IN3 w0.102: v1(94.12,52.25) 92.37,52.25 91.13,51.01 89.95,51.01 88.56,51.76 88.52,51.76 88.45,51.83
  IN3 w0.127: v1(90.02,70.71) 89.59,70.28 89.59,64.58 86.1,61.1 86.1,54.17 88.45,51.83
  BOTTOM w0.089: U21.BG30 91.3,75.77 91.4,75.67 91.4,75.31 91.12,75.03 91.12,74.07
  BOTTOM w0.127: 90.74,71.43 91.12,73.1 91.12,74.07
  BOTTOM w0.14: v1(90.02,70.71) 90.74,71.43 ; U26.H3 v1(94.12,52.25)
M_B_DQ2: length 33
  IN3 w0.102: 88.45,53.2 88.99,52.66 94.53,52.66 v1(94.94,53.07)
  IN3 w0.127: 88.45,53.2 87.03,54.62 87.03,59.6 90.5,63.07 90.5,68.45 90.95,68.89 90.95,72.73 90.26,73.42 v1(90.11,73.42)
  BOTTOM w0.089: v1(90.11,73.42) 90.5,73.81 90.5,75.72 U21.BH31
  BOTTOM w0.14: v1(94.94,53.07) U26.G2
M_B_DQ3: length 33.7
  IN3 w0.102: 88.83,52.39 90,52.39 v1(90.14,52.25)
  IN3 w0.127: v1(90.11,72.77) 90.45,72.77 90.72,72.5 90.72,69.09 90.2,68.57 90.2,64.2 90.08,64.08 90.08,63.64 90.2,63.52 90.2,63.2 89.99,62.99 89.81,62.99 89.72,63.07 89.54,63.07 89.36,62.89 89.36,62.71 89.45,62.63 89.45,62.45 89.11,62.12 88.88,62.12 88.64,62.35 88.53,62.47 88.35,62.47 88.16,62.29 88.16,62.11 88.55,61.73 88.55,61.55 88.37,61.37 88.19,61.37 87.81,61.75 87.63,61.75 87.45,61.57 87.45,61.39 87.83,61.01 87.83,60.83 87.65,60.65 87.47,60.65 87.22,60.9 87.04,60.9 86.81,60.67 86.81,60.49 87.06,60.24 87.06,60.06 86.72,59.72 86.72,54.5 88.83,52.39
  BOTTOM w0.089: 90.69,74.23 90.69,75.49 90.97,75.77 90.97,76 90.66,76.3 U21.BG31
  BOTTOM w0.127: v1(90.11,72.77) 90.69,73.36 90.69,74.23
  BOTTOM w0.14: U26.H8 90.14,52.27 v1(90.14,52.25)
M_B_DQ4: length 32.4
  IN3 w0.102: v1(91.76,54.67) 92.08,54.67 92.19,54.78 92.19,54.95 92.07,55.07 89.15,55.07 89.02,55.2
  IN3 w0.114: 89.02,55.2 88.89,55.33 88.89,58.11 89.08,58.3
  IN3 w0.127: 89.08,58.3 89.08,58.62 89.52,59.07 89.52,59.4 89.72,59.59 90.05,59.59 90.24,59.79 90.24,60.15 90.86,60.77 91.1,60.77 91.47,60.39 91.66,60.39 92.84,61.57 92.84,61.9 92.97,62.04 93.08,62.04 93.21,62.16 93.21,62.42 93.08,62.54 92.69,62.54 92.56,62.68 92.56,62.92 92.69,63.05 93.08,63.05 93.21,63.17 93.21,63.69 93.07,63.82 92.93,63.82 92.8,63.95 92.8,64.2 92.93,64.33 93.07,64.33 93.2,64.46 93.2,64.71 93.07,64.84 92.93,64.84 92.8,64.97 92.8,65.22 92.93,65.35 93.07,65.35 93.2,65.47 93.2,65.73 93.07,65.86 92.93,65.86 92.8,65.98 92.8,66.24 92.93,66.36 93.07,66.36 93.2,66.49 93.2,66.74 93.07,66.87 92.92,66.87 92.79,67 92.79,67.25 92.92,67.38 93.07,67.38 93.2,67.51 93.2,67.76 93.07,67.89 92.75,67.89 92.58,68.06 92.58,71.07 92.18,71.47 v1(91.92,71.47)
  BOTTOM w0.089: v1(91.92,71.47) 92.51,72.06 92.51,75.88 U21.BH27
  BOTTOM w0.14: U26.F7 91.74,54.67 v1(91.76,54.67)
M_B_DQ5: length 32.1
  IN3 w0.102: 89.71,58.83 89.71,56.07 89.9,55.88 92.11,55.88 92.35,55.64 92.35,55.46 92.46,55.36 93.06,55.36 93.16,55.46 93.16,56.04 93.26,56.14 93.47,56.14 93.57,56.04 93.57,55.4 93.9,55.07 94.28,55.07 94.53,54.82 94.53,54.28 v1(94.94,53.88)
  IN3 w0.127: v1(91.92,72.13) 91.95,72.13 92.83,71.26 92.83,68.62 93.52,67.92 93.52,61.82 91.7,60.01 90.9,60.01 89.71,58.83
  BOTTOM w0.089: U21.BG27 92.33,76.11 92.23,76.01 92.23,75.77 92.34,75.59 92.34,72.55 v1(91.92,72.13)
  BOTTOM w0.14: U26.F2 95.34,54.28 v1(94.94,53.88)
M_B_DQ6: length 31.3
  IN3 w0.114: v1(90.14,54.67) 89.25,54.67 88.64,55.27 88.64,58.49
  IN3 w0.127: 88.64,58.49 88.64,58.98 90.89,61.23 91.07,61.23 91.48,60.82 91.66,60.82 91.84,61 91.84,61.18 91.43,61.59 91.43,61.77 91.61,61.95 91.79,61.95 92.17,61.57 92.35,61.57 92.53,61.75 92.53,61.92 92.15,62.31 92.15,62.49 92.15,63.06 92.27,63.19 92.4,63.19 92.53,63.32 92.53,63.57 92.4,63.7 92.21,63.7 92.08,63.82 92.08,64.08 92.21,64.21 92.4,64.21 92.53,64.33 92.53,64.59 92.4,64.71 92.21,64.71 92.08,64.84 92.08,65.09 92.21,65.22 92.4,65.22 92.53,65.35 92.53,65.6 92.4,65.73 92.21,65.73 92.08,65.86 92.08,66.11 92.21,66.24 92.4,66.24 92.53,66.36 92.53,66.62 92.4,66.75 92.21,66.75 92.08,66.87 92.08,67.13 92.21,67.25 92.48,67.25 92.6,67.38 92.6,67.63 92.48,67.76 92.19,67.76 92.05,67.89 92.05,68.15 92.34,68.44 92.34,70.38 v1(91.92,70.81)
  BOTTOM w0.089: 92.15,71.04 92.69,71.58 92.69,75.63 92.85,75.78 92.85,76.13 U21.BG26
  BOTTOM w0.102: v1(91.92,70.81) 92.15,71.04
  BOTTOM w0.14: v1(90.14,54.67) 90.16,54.67 U26.F8
M_B_DQ7: length 32.8
  IN3 w0.102: v1(91.75,52.25) 91.75,52.02 91.57,51.84 89.98,51.84 89.73,52.08 89.58,52.08 89.49,52 89.49,51.84 89.38,51.73 89.12,51.73 89,51.85 89,52.01 88.94,52.07
  IN3 w0.127: 88.94,52.07 88.69,52.07 86.42,54.34 86.42,60.98 88.4,62.96 88.57,62.96 88.72,62.82 88.9,62.82 89.08,63 89.08,63.18 88.94,63.32 88.94,63.49 89.12,63.68 89.3,63.68 89.41,63.56 89.59,63.56 89.77,63.74 89.77,63.92 89.65,64.04 89.65,64.21 89.9,64.45 89.9,68.71 90.49,69.31 90.49,71.3 90.37,71.42 v1(90.02,71.42)
  BOTTOM w0.089: 90.91,74.18 90.91,75.39 91,75.49 U21.BJ30
  BOTTOM w0.127: 90.91,74.18 90.91,73.19 90.53,72.81 90.53,71.67 90.28,71.42 v1(90.02,71.42)
  BOTTOM w0.14: U26.H7 91.75,52.28 v1(91.75,52.25)
M_B_DQ8: length 40
  TOP w0.14: v1(94.94,52.25) 94.94,52.29 U10.H7
  IN1 w0.102: v1(91.13,79.76) 90.91,79.76 90.2,79.04 90.2,74.59 90.55,74.24 90.55,69.37 89.81,68.63 89.81,65.72 86.13,62.04 86.13,54.65 89.75,51.03 91.15,51.03 92.5,52.38 93.39,52.38 93.93,51.84 94.52,51.84 v1(94.94,52.25)
  BOTTOM w0.127: U21.BA30 90.91,79.76 v1(91.13,79.76)
M_B_DQ9: length 39.2
  TOP w0.14: v1(90.95,52.25) 90.95,52.28 U10.H3
  IN1 w0.102: v1(91.14,79.03) 90.54,79.03 90.4,78.89 90.4,74.69 90.49,74.6 90.84,74.25 90.84,68.82 90.72,68.7 90.3,68.7 90.17,68.58 90.17,68.37 90.3,68.25 90.72,68.25 90.84,68.13 90.84,67.9 90.72,67.79 90.23,67.79 90.1,67.66 90.1,67.46 90.23,67.33 90.72,67.33 90.84,67.22 90.84,66.99 90.72,66.87 90.23,66.87 90.1,66.75 90.1,66.54 90.23,66.42 90.72,66.42 90.84,66.3 90.84,66.07 90.72,65.96 90.23,65.96 90.1,65.83 90.1,65.6 87.37,62.86 87.37,62.7 87.73,62.34 87.73,62.18 87.57,62.02 87.41,62.02 87.05,62.38 86.88,62.38 86.42,61.92 86.42,54.92 89.5,51.85 90.55,51.85 v1(90.95,52.25)
  BOTTOM w0.127: U21.BB30 90.68,79.11 90.79,79.23 90.94,79.23 v1(91.14,79.03)
M_B_DQ10: length 39.8
  TOP w0.14: v1(90.95,53.07) 90.95,53.08 U10.G2
  IN1 w0.102: v1(90.95,53.07) 90.95,53.34 90.81,53.48 88.69,53.48 87.01,55.16 87.01,60.63 88.69,62.31 88.69,62.47 88.48,62.68 88.48,62.84 88.64,63 88.8,63 89.01,62.79 89.17,62.79 89.33,62.96 89.33,63.12 89.12,63.33 89.12,63.49 89.29,63.65 89.45,63.65 89.66,63.44 89.82,63.44 89.98,63.6 89.98,63.76 89.77,63.97 89.77,64.14 89.93,64.3 90.09,64.3 90.3,64.09 90.47,64.09 90.63,64.25 90.63,64.41 90.42,64.62 90.42,64.78 90.58,64.94 90.74,64.94 90.95,64.73 91.11,64.73 91.42,65.04 91.42,65.34 91.54,65.45 91.69,65.45 91.82,65.58 91.82,65.78 91.69,65.91 91.54,65.91 91.42,66.02 91.42,66.25 91.54,66.36 91.69,66.36 91.82,66.49 91.82,66.69 91.69,66.82 91.54,66.82 91.42,66.94 91.42,67.16 91.54,67.28 91.69,67.28 91.82,67.41 91.82,67.61 91.69,67.74 91.54,67.74 91.42,67.85 91.42,68.08 91.54,68.19 91.69,68.19 91.82,68.32 91.82,68.52 91.69,68.65 91.54,68.65 91.42,68.76 91.42,68.99 91.54,69.11 91.69,69.11 91.82,69.23 91.82,69.44 91.69,69.57 91.54,69.57 91.42,69.68 91.42,74.33 90.8,74.95 90.8,75.05 90.91,75.15 91.87,75.15 91.98,75.27 91.98,75.43 91.87,75.55 90.91,75.55 90.8,75.65 90.8,75.86 90.91,75.96 91.35,75.96 91.45,76.06 91.45,76.26 91.35,76.37 90.91,76.37 90.8,76.47 90.8,77.54 90.92,77.66 v1(91.13,77.66)
  BOTTOM w0.102: U21.BE30 90.86,77.39 v1(91.13,77.66)
M_B_DQ11: length 38
  TOP w0.14: U10.H8 95.75,52.28 v1(95.75,52.25)
  IN1 w0.102: v1(91.12,78.35) 90.6,77.83 90.6,74.84 91.13,74.32 91.13,65.95 88.02,62.85 88.02,62.06 87.51,61.54 87.34,61.54 87.04,61.85 86.86,61.85 86.71,61.7 86.71,61.52 87.02,61.22 87.02,61.05 86.71,60.75 86.71,55.04 89.1,52.66 95.34,52.66 v1(95.75,52.25)
  BOTTOM w0.127: U21.BD30 90.88,78.1 v1(91.12,78.35)
M_B_DQ12: length 37.5
  TOP w0.14: v1(91.76,55.48) 91.75,55.48 U10.E3
  IN1 w0.102: v1(91.76,55.48) 92.37,55.48 92.49,55.35 92.49,55.17 92.39,55.07 89.09,55.07 88.89,55.28 88.89,58.4 93.66,63.17 93.66,63.83 93.78,63.95 94.21,63.95 94.32,64.06 94.32,64.29 94.21,64.4 93.78,64.4 93.66,64.52 93.66,64.75 93.78,64.86 94.21,64.86 94.32,64.97 94.32,65.2 94.21,65.32 93.78,65.32 93.66,65.43 93.66,65.66 93.78,65.77 94.21,65.77 94.32,65.89 94.32,66.12 94.21,66.23 93.78,66.23 93.66,66.35 93.66,66.57 93.78,66.69 94.21,66.69 94.32,66.8 94.32,67.03 94.21,67.15 93.78,67.15 93.66,67.26 93.66,67.49 93.78,67.6 94.21,67.6 94.32,67.72 94.32,67.95 94.21,68.06 93.78,68.06 93.66,68.17 93.66,68.4 93.78,68.52 94.21,68.52 94.32,68.63 94.32,68.86 94.21,68.97 93.78,68.97 93.66,69.09 93.66,69.32 93.78,69.43 94.21,69.43 94.32,69.55 94.32,69.77 94.21,69.89 93.78,69.89 93.66,70 93.66,71.71 94.08,72.13 94.08,75.59 93.06,76.61 v1(93.06,77.02)
  BOTTOM w0.14: U21.BE25 93.11,77.02 v1(93.06,77.02)
M_B_DQ13: length 38.4
  TOP w0.14: U10.F2 90.94,54.67 v1(90.95,54.67)
  IN1 w0.102: v1(92.99,78.48) 92.7,78.48 92.58,78.35 92.58,76.76 93.86,75.47 93.86,72.21 93.37,71.73 93.37,64.05 93.27,63.95 93.14,63.95 92.9,64.18 92.74,64.18 92.58,64.02 92.58,63.86 93.18,63.26 93.18,63.1 93.02,62.94 92.85,62.94 92.26,63.54 92.09,63.54 91.93,63.38 91.93,63.21 92.53,62.62 92.53,62.45 92.37,62.29 92.21,62.29 91.61,62.89 91.45,62.89 91.29,62.73 91.29,62.57 91.88,61.97 91.88,61.81 91.72,61.65 91.56,61.65 90.96,62.24 90.8,62.24 90.64,62.08 90.64,61.92 91.24,61.32 91.24,61.16 89.28,59.2 89.12,59.2 88.84,59.47 88.66,59.47 88.52,59.33 88.52,59.15 88.79,58.88 88.79,58.72 88.57,58.49 88.57,55.11 89.42,54.26 90.87,54.26 90.95,54.34 v1(90.95,54.67)
  BOTTOM w0.14: U21.BB27 92.67,78.81 92.99,78.49 v1(92.99,78.48)
M_B_DQ14: length 38
  TOP w0.14: U10.F8 95.4,54.28 v1(95.75,54.63)
  IN1 w0.102: v1(93.03,77.77) 93.28,77.77 93.47,77.58 93.47,76.68 93.56,76.59 93.75,76.59 94.08,76.92 94.24,76.92 94.4,76.76 94.4,76.6 94.04,76.23 94.04,76.08 94.17,75.95 94.79,75.95 94.91,75.83 94.91,75.6 94.79,75.49 94.41,75.49 94.29,75.38 94.29,71.91 93.94,71.56 93.94,70.57 94.09,70.41 94.3,70.41 94.52,70.64 94.77,70.64 94.88,70.53 94.88,70.06 94.65,69.83 94.65,63.75 89.9,59 89.9,58.98 89.72,58.79 89.72,56.13 89.96,55.88 91.99,55.88 92.16,55.71 92.52,55.71 92.72,55.5 92.72,55.2 92.86,55.06 93.05,55.06 93.15,55.16 93.15,56.01 93.26,56.11 93.46,56.11 93.56,56.01 93.56,55.16 93.66,55.06 95.67,55.06 95.75,54.98 v1(95.75,54.63)
  BOTTOM w0.14: v1(93.03,77.77) 93.14,77.77 93.47,78.1 U21.BD25
M_B_DQ15: length 38.6
  TOP w0.14: v1(94.94,54.65) 94.56,54.28 U10.F7
  IN1 w0.102: v1(94.94,54.65) 94.34,54.06 92.62,54.06 92.61,54.07 89.29,54.07 88.25,55.11 88.25,60.11 88.4,60.26 88.56,60.26 88.96,59.85 89.14,59.85 89.29,59.99 89.29,60.17 88.88,60.58 88.88,60.74 89.04,60.9 89.2,60.9 89.8,60.31 89.98,60.31 90.12,60.45 90.12,60.63 89.53,61.23 89.53,61.39 89.69,61.55 89.85,61.55 90.44,60.96 90.62,60.96 90.77,61.1 90.77,61.28 90.17,61.87 90.17,62.03 93.08,64.94 93.08,70.87 93.03,70.91 93.03,75.92 92.17,76.78 v1(92.17,77.76)
  BOTTOM w0.14: v1(92.17,77.76) 92.16,77.76 92.51,78.1 U21.BD27
M_B_DQ16: length 24.1
  IN3 w0.102: v1(90.94,56.29) 91.36,56.71 91.36,58.05 91.59,58.29 92.08,58.29 92.54,58.74 92.54,58.87
  IN3 w0.127: 92.54,58.87 92.54,59.2 94.66,61.32 94.66,65.65 95.16,66.14 95.16,67.65 93.55,69.26 93.55,71.64 93.02,72.17 93.02,72.6 v1(93.45,73.02)
  BOTTOM w0.089: U21.BG24 93.93,76.24 93.93,75.92 94.18,75.67 94.18,73.76 v1(93.45,73.02)
  BOTTOM w0.14: v1(90.94,56.29) U26.D7
M_B_DQ17: length 21.5
  IN3 w0.127: v1(94.76,72.42) 94.98,72.42 95.43,71.98 95.43,70.12 97.34,68.2 97.34,65.24 96.9,64.79 96.9,64.59 97.03,64.46 97.17,64.46 97.29,64.34 97.29,64.08 97.17,63.95 97.03,63.95 96.9,63.83 96.9,63.57 97.03,63.45 97.18,63.45 97.3,63.32 97.3,63.07 97.18,62.94 97.03,62.94 96.9,62.81 96.9,62.56 97.03,62.43 97.16,62.43 97.28,62.3 97.28,62.05 97.16,61.92 97.03,61.92 96.9,61.8 96.9,60.28 95.75,59.13 v1(95.75,58.93)
  BOTTOM w0.089: 95.61,73.98 95.61,74.35 95.76,74.5 U21.BJ20
  BOTTOM w0.14: U26.A2 95.35,58.53 v1(95.75,58.93) ; v1(94.76,72.42) 95.34,72.42 95.61,72.7 95.61,73.98
M_B_DQ18: length 22.6
  IN3 w0.102: v1(91.76,57.88) 91.82,57.82 92.21,57.82 92.55,58.16 92.93,58.16 93.08,58.31 93.08,58.7 92.91,58.87
  IN3 w0.127: 92.91,58.87 92.91,59.14 94.97,61.2 94.97,65.52 95.46,66.02 95.46,67.8 93.79,69.48 93.79,72.3 93.7,72.39 v1(93.45,72.39)
  BOTTOM w0.089: v1(93.45,72.39) 93.83,72.39 94.36,72.91 94.36,75.87 U21.BH23
  BOTTOM w0.14: U26.A7 91.63,58.28 91.76,58.15 v1(91.76,57.88)
M_B_DQ19: length 23.4
  IN3 w0.102: v1(90.95,57.88) 90.95,58.12 91.39,58.56 91.39,58.87
  IN3 w0.127: 91.39,58.87 91.39,59.04 91.51,59.17 92.05,59.17 94.36,61.48 94.36,66.01 94.49,66.14 94.73,66.14 94.85,66.27 94.85,66.52 94.73,66.65 94.49,66.65 94.36,66.78 94.36,67.03 94.49,67.16 94.72,67.16 94.85,67.28 94.85,67.54 94.72,67.67 94.46,67.67 94.36,67.76 94.36,67.99 93.31,69.04 93.31,71.54 92.78,72.07 92.78,73.38 93.15,73.75 93.37,73.75 v1(93.45,73.67)
  BOTTOM w0.089: U21.BJ24 94,75.39 94,75.3 93.85,75.14 93.85,74.76 94,74.61 94,74.47 93.87,74.34 93.87,74.18 94,74.05 94,73.82 93.84,73.67 v1(93.45,73.67)
  BOTTOM w0.14: U26.B8 90.8,57.48 90.95,57.62 v1(90.95,57.88)
M_B_DQ20: length 21.3
  IN3 w0.127: v1(94.94,58.68) 95.04,58.58 95.2,58.58 95.32,58.69 95.32,59.25 96.59,60.52 96.59,64.92 97.04,65.36 97.04,67.98 95.18,69.83 95.18,71.67 95.09,71.76 v1(94.76,71.76)
  BOTTOM w0.089: U21.BG20 95.76,75.93 96.04,75.66 96.04,74.46 95.91,74.33 95.91,74.24
  BOTTOM w0.14: 95.91,74.24 95.91,72.6 95.08,71.76 v1(94.76,71.76) ; U26.A3 94.94,58.67 v1(94.94,58.68)
M_B_DQ21: length 23.7
  IN3 w0.102: 96.8,59.19 96.34,59.19 96.16,59.01 96.16,56.73 v1(95.75,56.32)
  IN3 w0.127: 96.8,59.19 97.08,59.19 97.65,59.76 97.65,68.45 95.67,70.43 95.67,72.15 v1(94.76,73.06)
  BOTTOM w0.089: 95.36,74.37 95.49,74.49 95.49,75.66 95.58,75.76 95.58,76.03 95.43,76.19 U21.BG21
  BOTTOM w0.14: v1(95.75,56.32) 95.4,56.68 U26.C2 ; v1(94.76,73.06) 95.36,73.66 95.36,74.37
M_B_DQ22: length 21.9
  IN3 w0.102: 94.53,58.83 94.53,57.49 v1(94.94,57.08)
  IN3 w0.127: 94.53,58.83 94.53,58.95 96.27,60.69 96.27,65.03 96.73,65.49 96.73,67.78 94.76,69.75 94.76,71.1 v1(94.76,71.1)
  BOTTOM w0.089: 96.18,74.21 96.24,74.27 96.24,75.87 U21.BH19
  BOTTOM w0.14: U26.C3 94.55,56.69 v1(94.94,57.08) ; v1(94.76,71.1) 96.18,72.52 96.18,74.21
M_B_DQ23: length 24
  IN3 w0.102: 90.47,58.83 90.47,58.41 90.54,58.34 90.54,57.49 v1(90.14,57.08)
  IN3 w0.127: 90.47,58.83 91.12,59.47 91.93,59.47 94.05,61.6 94.05,67.87 93.07,68.86 93.07,71.39 92.49,71.97 92.49,73.92 92.87,74.3 v1(93.45,74.3)
  BOTTOM w0.089: U21.BG25 93.22,76.09 93.16,75.94 93.16,75.77 93.25,75.67 93.25,75.33 93.05,75.12 93.05,74.7 v1(93.45,74.3)
  BOTTOM w0.14: U26.C8 90.54,56.68 v1(90.14,57.08)
M_B_DQ24: length 32.4
  TOP w0.14: v1(91.85,58.7) 91.84,58.7 91.41,58.28 U10.A3
  IN1 w0.102: v1(91.85,58.7) 91.85,58.97 91.95,59.06 92.13,59.06 92.57,58.63 92.75,58.63 92.89,58.77 92.89,58.95 92.46,59.39 92.46,59.57 96.76,63.88 96.76,70.67 95.9,71.53 95.9,72.98 96,73.08 96.37,73.08 96.49,73.2 96.49,73.37 96.37,73.48 96,73.48 95.9,73.59 95.9,73.79 96,73.89 96.37,73.89 96.48,74.01 96.48,74.18 96.37,74.3 96,74.3 95.9,74.4 95.9,74.6 96,74.7 96.34,74.7 96.46,74.82 96.46,74.99 96.34,75.11 96,75.11 95.9,75.21 95.9,75.41 96,75.52 96.29,75.52 96.4,75.64 96.4,75.8 96.29,75.92 96,75.92 95.9,76.02 95.9,76.42 94.01,78.31 94.01,78.9 93.53,79.38 93.53,80.76 v1(93.06,81.24)
  BOTTOM w0.14: U21.AT27 92.55,81.54 92.85,81.24 v1(93.06,81.24)
M_B_DQ25: length 32.3
  TOP w0.14: U10.C2 90.51,56.68 v1(90.12,56.3)
  IN1 w0.102: v1(90.12,56.3) 90.42,56.3 90.54,56.43 90.54,58.9 95.17,63.53 95.17,69.36 95.29,69.47 95.83,69.47 95.96,69.6 95.96,69.8 95.83,69.93 95.29,69.93 95.17,70.04 95.17,70.27 95.29,70.39 95.68,70.39 95.81,70.51 95.81,70.72 95.68,70.84 95.29,70.84 95.17,70.96 95.17,76.29 93.4,78.06 93.4,78.65 92.47,79.58 92.47,80.06 92.6,80.19 92.6,80.75 92.48,80.88 92.16,80.88 92.07,80.8 v1(92.07,80.46)
  BOTTOM w0.14: U21.AW29 91.83,80.46 v1(92.07,80.46)
M_B_DQ26: length 31.3
  TOP w0.14: v1(94.12,58.68) 94.52,58.28 U10.A7
  IN1 w0.102: v1(93.01,81.87) 93.54,81.34 93.54,81.25 93.78,81.01 94.21,81.01 95.86,79.36 95.86,77.44 97.76,75.55 97.76,70.64 98.02,70.38 98.02,62.76 97.33,62.07 97.17,62.07 97.02,62.21 96.86,62.21 96.69,62.05 96.69,61.89 96.84,61.74 96.84,61.58 96.68,61.42 96.52,61.42 96.37,61.57 96.21,61.57 96.05,61.41 96.05,61.24 96.2,61.1 96.2,60.93 96.03,60.77 95.87,60.77 95.72,60.92 95.56,60.92 95.4,60.76 95.4,60.6 95.55,60.45 95.55,60.29 95.39,60.13 95.23,60.13 95.08,60.27 94.92,60.27 94.75,60.11 94.75,59.95 94.9,59.8 94.9,59.64 94.74,59.48 94.58,59.48 94.43,59.63 94.27,59.63 94.12,59.48 v1(94.12,58.68)
  BOTTOM w0.14: U21.AR27 93.01,81.91 v1(93.01,81.87)
M_B_DQ27: length 29.3
  TOP w0.14: v1(94.94,56.31) 94.94,56.3 94.55,55.91 U10.D7
  IN1 w0.102: v1(94.94,56.31) 94.53,56.72 94.53,58.86 94.84,59.16 94.92,59.16 98.44,62.67 98.44,70.41 97.97,70.88 97.97,75.7 96.17,77.5 96.17,79.41 v1(94.82,81.28)
  BOTTOM w0.14: U21.AT23 94.47,81.66 94.82,81.31 v1(94.82,81.28)
M_B_DQ28: length 29.4
  TOP w0.14: v1(91.75,56.29) 91.75,56.28 U10.C3
  IN1 w0.102: v1(91.75,56.29) 91.43,56.29 91.36,56.37 91.36,58.89 96.47,64 96.47,70.67 95.69,71.44 95.69,76.34 93.81,78.23 93.81,78.82 93.33,79.29 93.33,80.37 93.19,80.51 v1(93.01,80.51)
  BOTTOM w0.14: U21.AV27 92.98,80.51 v1(93.01,80.51)
M_B_DQ29: length 31.6
  TOP w0.14: v1(95.75,57.88) U10.B8
  IN1 w0.102: v1(94.89,81.92) 95.63,81.17 96.62,81.17 97.66,80.13 97.66,76.39 98.89,75.16 98.89,72.19 98.79,72.08 98.49,72.08 98.39,71.98 98.39,71.78 98.49,71.68 98.79,71.68 98.89,71.58 98.89,71.37 98.79,71.27 98.49,71.27 98.39,71.17 98.39,70.97 98.49,70.87 98.79,70.87 98.89,70.76 98.89,62.71 95.34,59.17 95.34,58.29 v1(95.75,57.88)
  BOTTOM w0.102: U21.AR25 93.78,82.06 94.74,82.06 v1(94.89,81.92)
M_B_DQ30: length 30.1
  TOP w0.14: v1(95.75,57.03) 95.4,56.68 U10.C8
  IN1 w0.102: v1(95.75,57.03) 95.75,57.3 96.16,57.71 96.16,59.12 99.18,62.14 99.18,75.34 97.86,76.66 97.86,80.22 96.44,81.64 v1(94.92,82.64)
  BOTTOM w0.14: v1(94.92,82.64) 94.64,82.37 U21.AR23
M_B_DQ31: length 31.3
  TOP w0.14: U10.A2 90.55,58.29 v1(90.95,58.69)
  IN1 w0.102: v1(92.93,79.88) 92.93,79.41 93.6,78.73 93.6,78.14 95.46,76.28 95.46,71.36 96.18,70.65 96.18,69.25 96.06,69.14 95.63,69.14 95.52,69.03 95.52,68.8 95.63,68.68 96.06,68.68 96.18,68.57 96.18,68.34 96.06,68.23 95.63,68.23 95.52,68.11 95.52,67.88 95.63,67.77 96.06,67.77 96.18,67.65 96.18,67.43 96.06,67.31 95.63,67.31 95.52,67.2 95.52,66.97 95.63,66.85 96.06,66.85 96.18,66.74 96.18,66.51 96.06,66.4 95.63,66.4 95.52,66.28 95.52,66.05 95.63,65.94 96.06,65.94 96.18,65.83 96.18,65.6 96.06,65.48 95.63,65.48 95.52,65.37 95.52,65.08 95.63,64.96 96.06,64.96 96.18,64.85 96.18,64.62 96.06,64.51 95.63,64.51 95.52,64.39 95.52,63.46 90.95,58.9 v1(90.95,58.69)
  BOTTOM w0.14: v1(92.93,79.88) 92.9,79.88 U21.AW27
M_B_DQ32: length 31.1
  IN3 w0.102: v1(102.2,77.46) 102.54,77.12 104.91,77.12 105.49,76.54 107.16,76.54 107.85,75.84 107.99,75.84 108.51,76.36 108.68,76.36 108.8,76.24 108.8,76.07 108.28,75.56 108.28,75.41 108.43,75.27 108.57,75.27 109.23,75.93 109.4,75.93 109.52,75.81 109.52,75.65 108.86,74.98 108.86,74.84 110.02,73.68
  IN3 w0.127: 110.02,73.68 111.89,71.81 111.89,61.81 112.39,61.3 112.39,60.58 113.66,59.31 v1(113.66,59.1)
  BOTTOM w0.14: U27.A2 113.66,58.68 v1(113.66,59.1) ; v1(102.2,77.46) 102.2,76.99 102.51,76.68 U21.BF6
M_B_DQ33: length 31.3
  IN3 w0.102: 105.42,76.3 104.8,76.91 102.48,76.91 101.98,77.1 101.79,77.29 101.79,78.07 101.64,78.35 v1(101.28,78.72) ; v1(113.66,56.28) 113.25,56.9 113.25,59.29 112.99,59.54
  IN3 w0.114: 106.92,76.3 105.42,76.3
  IN3 w0.127: 112.99,59.54 112.09,60.45 112.09,61.1 111.58,61.61 111.58,71.64 106.92,76.3
  BOTTOM w0.14: v1(101.28,78.72) 101.26,78.72 U21.BD10 ; v1(113.66,56.28) U27.C2
M_B_DQ34: length 30.6
  IN3 w0.102: v1(108.84,56.29) 109.05,56.29 109.54,56.78 109.54,57.43 109.26,57.71 109.26,59.1 ; v1(99.31,77.76) 99.31,77.76 99.31,77.47 100.93,75.85 101.45,75.85 101.61,75.7 104.19,75.7 105.08,74.81 105.31,74.81 108.23,71.89
  IN3 w0.127: 109.26,59.1 109.26,59.22 108.98,59.5 108.44,59.5 108.31,59.63 108.31,59.92 108.44,60.05 108.78,60.05 108.97,60.25 108.97,71.14 108.23,71.89
  BOTTOM w0.14: v1(108.84,56.29) U27.D7 ; v1(99.31,77.76) 98.82,77.76 98.73,77.67 U21.BE14
M_B_DQ35: length 30
  IN3 w0.102: v1(112.84,58.72) 112.84,59.26 112.65,59.45 ; 105.34,76.06 104.69,76.71 102.08,76.71 101.59,77.21 101.59,77.99 101.31,78.27 100.78,78.27 100.61,78.44 100.61,78.98 100.33,79.27 v1(100.16,79.27)
  IN3 w0.114: 106.73,76.06 105.34,76.06
  IN3 w0.127: 106.73,76.06 111.28,71.51 111.28,61.48 111.78,60.98 111.78,60.32 112.65,59.45
  BOTTOM w0.14: U21.BB10 100.64,78.93 100.3,79.27 v1(100.16,79.27) ; v1(112.84,58.72) 112.84,58.48 112.64,58.28 U27.A3
M_B_DQ36: length 29.8
  IN3 w0.102: v1(108.04,57.08) 107.64,57.49 107.64,59.08 ; 104.46,74.79 104.21,75.04 103.72,75.29 101.44,75.29 100.76,75.45 99.07,77.13 98.69,77.52 98.69,79.18 v1(99.23,79.93)
  IN3 w0.127: 104.46,74.79 107.63,71.63 107.63,59.1 107.64,59.08
  BOTTOM w0.14: v1(108.04,57.08) 108.45,56.68 U27.C8 ; v1(99.23,79.93) 98.83,79.52 U21.BA14
M_B_DQ37: length 29.4
  IN3 w0.102: 108.29,59.1 108.45,58.94 108.45,58.29 v1(108.86,57.88) ; v1(99.19,79.11) 98.89,78.81 98.89,77.6 99.16,77.34 100.84,75.65 101.37,75.65 101.53,75.49 104.08,75.49 107.93,71.64 107.93,71.59
  IN3 w0.127: 108.29,59.1 107.93,59.46 107.93,60.23 108.06,60.36 108.43,60.36 108.55,60.48 108.55,60.74 108.43,60.86 108.06,60.86 107.93,60.99 107.93,71.59
  BOTTOM w0.14: U21.BB14 99.03,79.11 v1(99.19,79.11) ; v1(108.86,57.88) U27.B8
M_B_DQ38: length 30.4
  IN3 w0.102: v1(99.32,78.46) 99.6,78.46 99.72,78.34 99.72,77.78 99.72,77.41 99.9,77.23 100.33,77.23 100.43,77.13 100.43,76.64 101.01,76.06 101.54,76.06 101.7,75.9 104.3,75.9 105.08,75.11 105.44,75.11 108.44,72.11 ; 109.95,59.1 109.95,59.08 110.08,58.95 110.08,58.43 109.67,58.02 v1(109.67,57.88)
  IN3 w0.127: 108.44,72.11 109.28,71.27 109.28,60.79 109.41,60.67 109.86,60.67 109.99,60.54 109.99,60.29 109.86,60.16 109.41,60.16 109.28,60.03 109.28,59.73 109.41,59.61 109.86,59.61 109.95,59.52 109.95,59.1
  BOTTOM w0.14: U27.A7 109.66,57.88 v1(109.67,57.88) ; v1(99.32,78.46) 99.31,78.46 99.09,78.46 U21.BD14
M_B_DQ39: length 31.3
  IN3 w0.102: 109.35,73.01 106.54,75.82 105.27,75.82 104.58,76.51 102,76.51 101.64,76.87 v1(101.35,76.87) ; 112.3,59.1 112.44,58.96 112.44,57.23 112.58,57.09 v1(112.84,57.09)
  IN3 w0.127: 112.3,59.1 112.2,59.2 111.84,59.2 111.33,59.71 111.33,61 110.55,61.78 110.55,66.06 110.68,66.19 110.85,66.19 110.97,66.32 110.97,66.57 110.85,66.7 110.68,66.7 110.55,66.82 110.55,67.08 110.68,67.2 110.85,67.2 110.97,67.33 110.97,67.59 110.85,67.71 110.68,67.71 110.55,67.84 110.55,68.09 110.68,68.22 110.85,68.22 110.97,68.35 110.97,68.6 110.85,68.73 110.68,68.73 110.55,68.86 110.55,69.11 110.68,69.24 110.85,69.24 110.97,69.36 110.97,69.62 110.85,69.74 110.68,69.74 110.55,69.87 110.55,70.13 110.68,70.25 110.85,70.25 110.97,70.38 110.97,70.63 110.85,70.76 110.68,70.76 110.55,70.89 110.55,71.81 109.35,73.01
  BOTTOM w0.14: U27.C3 112.46,56.7 v1(112.84,57.09) ; v1(101.35,76.87) 101.35,77.15 U21.BE8
M_B_DQ40: length 54
  TOP w0.14: U11.H3 108.86,52.28 v1(108.86,52.25)
  IN3 w0.102: 113.84,51.03 112.65,51.03 111.44,52.16 110.33,52.16 109.83,51.85 109.53,51.85 v1(108.86,52.25) ; v1(100.13,80.23) 100.57,80.67 101.22,80.67 101.79,80.85 104.19,80.85 104.2,80.86
  IN3 w0.114: 104.2,80.86 108.73,80.86 109.21,80.38 ; 113.84,51.03 114.38,51.57 115.44,51.57
  IN3 w0.127: 115.44,51.57 118.75,54.89 118.75,73.68 112.05,80.38 109.21,80.38
  BOTTOM w0.14: v1(100.13,80.23) 100.12,80.23 U21.AV12
M_B_DQ41: length 54.1
  TOP w0.14: v1(113.66,54.65) 113.28,54.28 U11.F8
  IN3 w0.102: v1(102.83,78.3) 102.91,78.37 104.04,78.37 104.54,77.87 110.76,77.87 110.9,77.73 ; v1(113.66,54.65) 113.66,54.45 113.86,54.25 114.64,54.25 115.03,54.64
  IN3 w0.114: 115.03,54.64 115.46,55.07 115.46,58.78
  IN3 w0.127: 110.9,77.73 113.79,74.84 113.79,73.97 113.92,73.84 114.66,73.84 114.79,73.72 114.79,73.46 114.66,73.33 113.92,73.33 113.79,73.21 113.79,72.95 113.92,72.83 114.66,72.83 114.79,72.7 114.79,72.45 114.66,72.32 113.92,72.32 113.79,72.19 113.79,71.94 113.92,71.81 114.66,71.81 114.79,71.68 114.79,71.43 114.66,71.3 113.92,71.3 113.79,71.18 113.79,70.92 113.92,70.79 114.66,70.79 114.79,70.67 114.79,70.41 114.66,70.29 113.92,70.29 113.79,70.16 113.79,69.91 113.92,69.78 114.66,69.78 114.79,69.65 114.79,69.4 114.66,69.27 113.92,69.27 113.79,69.14 113.79,68.89 113.92,68.76 114.66,68.76 114.79,68.64 114.79,68.38 114.66,68.25 113.92,68.25 113.79,68.13 113.79,67.87 113.92,67.75 114.66,67.75 114.79,67.62 114.79,67.37 114.66,67.24 113.92,67.24 113.79,67.11 113.79,66.86 113.92,66.73 114.46,66.73 114.58,66.6 114.58,66.35 114.46,66.22 113.92,66.22 113.79,66.1 113.79,65.84 113.92,65.71 114.46,65.71 114.59,65.59 114.59,65.33 114.46,65.21 113.92,65.21 113.79,65.08 113.79,64.83 113.92,64.7 114.66,64.7 114.79,64.57 114.79,64.32 114.66,64.19 113.92,64.19 113.79,64.06 113.79,63.78 113.92,63.65 114.57,63.65 114.69,63.52 114.69,63.26 114.57,63.13 113.93,63.13 113.79,63 113.79,61.52 115.46,59.85 115.46,58.78
  BOTTOM w0.102: U21.BD6 102.83,78.25 v1(102.83,78.3)
M_B_DQ42: length 52.3
  TOP w0.14: v1(108.86,54.67) 108.84,54.67 U11.F2
  IN3 w0.102: v1(108.86,54.67) 108.86,54.97 108.98,55.09 109.12,55.09 109.17,55.14 109.44,55.14 109.53,55.06 109.87,55.06 110.43,55.62 111.3,55.62 111.86,55.06 114.66,55.06 ; v1(102.83,77.52) 102.83,77.72 103.26,78.15 103.96,78.15 104.48,77.63 110.57,77.63
  IN3 w0.114: 115.2,59.07 115.2,55.24 115.02,55.06 114.66,55.06
  IN3 w0.127: 115.2,59.07 115.2,59.3 115.14,59.36 115.14,59.74 114.92,59.96 114.74,59.96 114.58,59.8 114.4,59.8 114.22,59.98 114.22,60.16 114.38,60.32 114.38,60.5 114.2,60.68 114.02,60.68 113.84,60.5 113.66,60.5 113.48,60.68 113.48,60.86 113.66,61.04 113.66,61.22 113.49,61.39 113.49,62.25 113.36,62.37 112.85,62.37 112.73,62.5 112.73,62.75 112.85,62.88 113.36,62.88 113.49,63.01 113.49,63.26 113.36,63.39 112.85,63.39 112.73,63.52 112.73,63.77 112.85,63.9 113.36,63.9 113.49,64.02 113.49,64.28 113.36,64.41 112.85,64.41 112.73,64.53 112.73,64.79 112.85,64.91 113.36,64.91 113.49,65.04 113.49,65.29 113.36,65.42 112.85,65.42 112.73,65.55 112.73,65.8 112.85,65.93 113.36,65.93 113.49,66.06 113.49,66.31 113.36,66.44 112.85,66.44 112.73,66.56 112.73,66.82 112.85,66.95 113.36,66.95 113.49,67.07 113.49,72.2 113.36,72.33 112.55,72.33 112.43,72.45 112.43,72.71 112.55,72.83 113.36,72.83 113.49,72.96 113.49,73.22 113.36,73.34 112.85,73.34 112.73,73.47 112.73,73.72 112.85,73.85 113.36,73.85 113.49,73.98 113.49,74.27 113.36,74.4 112.61,74.4 112.54,74.46 112.54,74.72 112.93,75.11 112.93,75.28 110.57,77.63
  BOTTOM w0.102: v1(102.83,77.52) 102.83,77.58 U21.BD5
M_B_DQ43: length 53.7
  TOP w0.14: U11.F7 112.08,54.65 v1(112.03,54.65)
  IN3 w0.102: v1(112.03,54.65) 112.03,54.25 112.24,54.04 114.96,54.04 115.77,54.86 115.77,58.5 ; v1(101.55,79.29) 102.05,78.8 103.07,78.8 103.28,78.6 104.21,78.6 104.73,78.08 111.2,78.08 111.73,77.55
  IN3 w0.127: 111.73,77.55 115.09,74.19 115.09,73.94 115.22,73.81 115.47,73.81 115.6,73.69 115.6,73.43 115.47,73.31 115.22,73.31 115.09,73.18 115.09,72.93 115.22,72.8 115.63,72.8 115.76,72.67 115.76,72.42 115.63,72.29 115.22,72.29 115.09,72.16 115.09,71.91 115.22,71.78 115.63,71.78 115.76,71.66 115.76,71.4 115.63,71.27 115.22,71.27 115.09,71.15 115.09,70.89 115.22,70.77 115.63,70.77 115.76,70.64 115.76,70.39 115.63,70.26 115.22,70.26 115.09,70.13 115.09,69.88 115.22,69.75 115.63,69.75 115.76,69.62 115.76,69.37 115.63,69.24 115.22,69.24 115.09,69.12 115.09,68.86 115.22,68.73 115.63,68.73 115.76,68.61 115.76,68.35 115.63,68.23 115.22,68.23 115.09,68.1 115.09,67.85 115.22,67.72 115.63,67.72 115.76,67.59 115.76,67.34 115.63,67.21 115.07,67.21 114.94,67.08 114.94,66.83 115.07,66.7 115.63,66.7 115.76,66.58 115.76,66.32 115.63,66.19 114.92,66.19 114.79,66.07 114.79,65.81 114.92,65.69 115.63,65.69 115.76,65.56 115.76,65.31 115.63,65.18 115.22,65.18 115.09,65.05 115.09,62.86 114.97,62.73 114.22,62.73 114.1,62.6 114.1,62.35 114.22,62.22 114.97,62.22 115.09,62.09 115.09,61.84 114.97,61.71 114.54,61.71 114.41,61.59 114.41,61.33 114.54,61.2 114.97,61.2 115.09,61.08 115.09,60.65 115.77,59.97 115.77,58.51 115.77,58.5
  BOTTOM w0.14: v1(101.55,79.29) 101.78,79.07 U21.BB7
M_B_DQ44: length 53.1
  TOP w0.14: v1(113.66,52.25) 113.66,52.28 U11.H8
  IN3 w0.102: 115.84,52.89 115.2,52.25 v1(113.66,52.25) ; 111.59,79.64 111.48,79.64 111.42,79.7 106.04,79.7 105.74,80 103.9,80 103.72,79.82 101.5,79.82 101.43,79.75 101,79.75 100.83,79.92 v1(100.83,80.22)
  IN3 w0.127: 115.84,52.89 117.39,54.44 117.39,61.92 117.52,62.04 118.01,62.04 118.14,62.17 118.14,62.42 118.01,62.55 117.52,62.55 117.39,62.68 117.39,62.93 117.52,63.06 118.01,63.06 118.14,63.19 118.14,63.44 118.01,63.57 117.52,63.57 117.39,63.69 117.39,63.95 117.52,64.08 118.01,64.08 118.14,64.2 118.14,64.46 118.01,64.58 117.52,64.58 117.39,64.71 117.39,64.96 117.52,65.09 118.01,65.09 118.14,65.22 118.14,65.47 118.01,65.6 117.52,65.6 117.39,65.73 117.39,65.98 117.52,66.11 118.01,66.11 118.14,66.23 118.14,66.49 118.01,66.62 117.52,66.62 117.39,66.74 117.39,67 117.52,67.12 118.01,67.12 118.14,67.25 118.14,67.5 118.01,67.63 117.52,67.63 117.39,67.76 117.39,68.01 117.52,68.14 118.01,68.14 118.14,68.27 118.14,73.4 111.9,79.64 111.59,79.64
  BOTTOM w0.14: v1(100.83,80.22) U21.AV10
M_B_DQ45: length 53.2
  TOP w0.14: v1(112.84,52.25) 112.84,52.29 U11.H7
  IN3 w0.102: v1(112.84,52.25) 113.25,51.85 115.23,51.85 ; v1(101.49,80.27) 101.87,80.65 104.21,80.65 104.57,80.29 105.91,80.29 106.21,79.99 111.73,79.99
  IN3 w0.127: 111.73,79.99 111.99,79.99 118.44,73.54 118.44,61.63 118.31,61.5 117.86,61.5 117.73,61.37 117.73,61.12 117.86,60.99 118.31,60.99 118.44,60.86 118.44,60.61 118.31,60.48 117.86,60.48 117.73,60.36 117.73,60.1 117.86,59.98 118.31,59.98 118.44,59.85 118.44,59.59 118.31,59.47 117.86,59.47 117.73,59.34 117.73,59.09 117.86,58.96 118.31,58.96 118.44,58.83 118.44,58.58 118.31,58.45 117.86,58.45 117.73,58.32 117.73,58.07 117.86,57.94 118.31,57.94 118.44,57.82 118.44,57.56 118.31,57.44 117.86,57.44 117.73,57.31 117.73,57.05 117.86,56.93 118.31,56.93 118.44,56.8 118.44,56.55 118.31,56.42 117.86,56.42 117.73,56.29 117.73,56.04 117.86,55.91 118.01,55.91 118.13,55.79 118.13,54.75 115.23,51.85
  BOTTOM w0.14: v1(101.49,80.27) 101.49,80.22 101.07,79.8 U21.AY9
M_B_DQ46: length 53.1
  TOP w0.14: v1(108.86,53.07) 108.86,53.08 U11.G2
  IN3 w0.102: v1(102.25,79.25) 102.62,79.62 104.13,79.62 104.27,79.48 104.87,79.48 105.07,79.68 105.76,79.68 105.95,79.49 111.22,79.49 111.47,79.24 111.73,79.24 ; 115.12,52.66 109.26,52.66 v1(108.86,53.07)
  IN3 w0.127: 115.12,52.66 117.06,54.61 117.06,68.39 117.19,68.52 117.66,68.52 117.79,68.65 117.79,68.9 117.66,69.03 117.19,69.03 117.06,69.15 117.06,69.41 117.19,69.53 117.66,69.53 117.79,69.66 117.79,69.92 117.66,70.04 117.19,70.04 117.06,70.17 117.06,70.42 117.19,70.55 117.66,70.55 117.79,70.68 117.79,70.93 117.66,71.06 117.19,71.06 117.06,71.19 117.06,71.44 117.19,71.57 117.66,71.57 117.79,71.69 117.79,71.95 117.66,72.07 117.19,72.07 117.06,72.2 117.06,72.46 117.19,72.58 117.66,72.58 117.79,72.71 117.79,72.96 117.66,73.09 117.19,73.09 117.06,73.22 117.06,74.02 111.85,79.24 111.73,79.24
  BOTTOM w0.102: v1(102.25,79.25) 101.78,79.73 U21.AY7
M_B_DQ47: length 53.4
  TOP w0.14: v1(109.67,55.48) 109.66,55.48 U11.E3
  IN3 w0.102: v1(103.5,77.52) 103.5,77.74 103.67,77.91 103.89,77.91 104.41,77.39 109.25,77.39 109.49,77.15 109.49,77 ; v1(109.67,55.48) 109.67,55.75 109.8,55.87 114.66,55.87 114.75,55.96
  IN3 w0.114: 114.75,55.96 114.91,56.11 114.91,58.87
  IN3 w0.127: 109.49,77 109.49,76.94 110.36,76.07 110.36,75.84 109.6,75.09 109.6,74.91 109.78,74.73 109.96,74.73 111.41,76.18 111.59,76.18 111.77,76 111.77,75.82 110.3,74.35 110.3,74.17 110.4,74.07 110.48,73.99 110.66,73.99 112.06,75.39 112.24,75.39 112.42,75.21 112.42,75.03 111.01,73.62 111.01,73.44 111.19,73.26 111.37,73.26 112.02,73.91 112.2,73.91 112.42,73.69 112.42,73.5 111.79,72.87 111.79,72.66 112.55,71.9 113.06,71.9 113.18,71.77 113.18,71.52 113.06,71.39 112.55,71.39 112.42,71.27 112.42,71.01 112.55,70.89 113.06,70.89 113.18,70.76 113.18,70.5 113.06,70.38 112.55,70.38 112.42,70.25 112.42,70 112.55,69.87 113.06,69.87 113.18,69.74 113.18,69.49 113.06,69.36 112.55,69.36 112.42,69.23 112.42,68.98 112.55,68.85 112.91,68.85 113.04,68.73 113.04,68.47 112.91,68.35 112.55,68.35 112.42,68.22 112.42,67.96 112.55,67.84 112.91,67.84 113.04,67.71 113.04,67.46 112.91,67.33 112.55,67.33 112.42,67.2 112.42,62.03 112.93,61.52 112.93,60.8 114.17,59.55 114.23,59.55 114.91,58.87
  BOTTOM w0.102: v1(103.5,77.52) 103.16,77.19 U21.BF5
M_B_DQ48: length 52.7
  IN1 w0.102: v1(107.1,80.41) 107.51,79.99 110.79,79.99 114.32,76.46 114.32,71.54 114.2,71.42 113.15,71.42 113.02,71.3 113.02,71.09 113.15,70.97 114.2,70.97 114.32,70.85 114.32,70.62 114.2,70.51 113.15,70.51 113.03,70.39 113.03,70.17 113.15,70.05 114.2,70.05 114.32,69.94 114.32,69.71 114.2,69.59 113.15,69.59 113.03,69.48 113.03,69.25 113.15,69.14 114.2,69.14 114.32,69.02 114.32,68.79 114.2,68.68 113.15,68.68 113.03,68.57 113.03,68.34 113.15,68.22 114.2,68.22 114.32,68.11 114.32,67.88 114.2,67.77 113.15,67.77 113.02,67.64 113.02,67.42 113.15,67.3 113.92,67.3 114.04,67.17 114.04,66.98 113.92,66.86 113.19,66.86 113.03,66.7 113.03,61.87 115.47,59.44 115.47,55.88 114.65,55.06 110.11,55.06 109.7,54.65 v1(109.66,54.65)
  BOTTOM w0.102: 105.32,81.01 105.27,80.96 104.85,80.96 104.57,81.24 U21.AU2
  BOTTOM w0.127: v1(107.1,80.41) 106.5,81.01 105.32,81.01
  BOTTOM w0.14: v1(109.66,54.65) 109.63,54.65 U27.F7
M_B_DQ49: length 54.3
  IN1 w0.102: v1(100.08,82.08) 100.57,82.57 105.22,82.57 105.22,82.57 111.67,82.57 116.73,77.5 116.73,64.71 118.34,63.1 118.34,55.03 115.27,51.96 114.76,51.96 113.82,51.02 112.54,51.02 111.1,52.47 109.87,52.47 v1(109.66,52.25)
  BOTTOM w0.127: v1(100.08,82.08) 100.35,81.8 U21.AT10
  BOTTOM w0.14: v1(109.66,52.25) 109.66,52.28 U27.H7
M_B_DQ50: length 54.1
  IN1 w0.102: v1(100.72,82.06) 101.15,81.63 101.6,81.63 102.33,82.36 105.01,82.36 105.1,82.27 111.54,82.27 116.44,77.38 116.44,64.59 117.59,63.44 117.59,62.98 117.7,62.86 117.94,62.86 118.05,62.75 118.05,62.52 117.94,62.4 117.7,62.4 117.59,62.29 117.59,62.06 117.7,61.95 117.94,61.95 118.05,61.83 118.05,61.6 117.94,61.49 117.7,61.49 117.59,61.38 117.59,61.15 117.7,61.03 117.94,61.03 118.05,60.92 118.05,60.69 117.94,60.57 117.7,60.57 117.59,60.46 117.59,60.23 117.7,60.12 117.94,60.12 118.05,60 118.05,59.77 117.94,59.66 117.7,59.66 117.59,59.55 117.59,59.32 117.7,59.2 117.94,59.2 118.05,59.09 118.05,58.86 117.94,58.75 117.7,58.75 117.59,58.63 117.59,58.4 117.7,58.29 117.94,58.29 118.05,58.17 118.05,57.95 117.94,57.83 117.7,57.83 117.59,57.72 117.59,57.49 117.7,57.37 117.94,57.37 118.05,57.26 118.05,57.03 117.94,56.92 117.7,56.92 117.59,56.8 117.59,54.74 115.26,52.41 114.39,52.41 113.83,51.85 112.44,51.85 v1(112.03,52.25)
  BOTTOM w0.127: U21.AT9 101.07,81.72 v1(100.72,82.06)
  BOTTOM w0.14: U27.H3 v1(112.03,52.25)
M_B_DQ51: length 50.8
  IN1 w0.102: v1(108.45,80.41) 108.66,80.61 110.58,80.61 114.61,76.58 114.61,66.56 114.5,66.44 113.45,66.44 113.32,66.32 113.32,66.11 113.45,65.99 114.5,65.99 114.61,65.87 114.61,65.64 114.5,65.53 113.45,65.53 113.32,65.4 113.32,65.2 113.45,65.07 114.5,65.07 114.61,64.96 114.61,64.73 114.5,64.62 113.45,64.62 113.32,64.49 113.32,64.29 113.45,64.16 114.5,64.16 114.61,64.04 114.61,63.82 114.5,63.7 113.45,63.7 113.32,63.57 113.32,63.37 113.45,63.24 114.5,63.24 114.61,63.13 114.61,62.9 114.5,62.79 113.45,62.79 113.32,62.66 113.32,62.46 113.45,62.33 114.48,62.33 114.6,62.21 114.6,62.04 114.48,61.91 113.89,61.91 113.77,61.79 113.77,61.62 113.89,61.5 114.45,61.5 114.61,61.34 114.61,60.71 115.76,59.56 115.76,55.88 114.95,55.08 114.95,54.56 114.64,54.25 112.97,54.25 112.84,54.37 v1(112.84,54.65)
  BOTTOM w0.127: v1(108.45,80.41) 108.45,80.93 108.12,81.26 105.04,81.26 U21.AU1
  BOTTOM w0.14: U27.F2 113.22,54.28 v1(112.84,54.65)
M_B_DQ52: length 51.8
  IN1 w0.102: v1(102.86,80.24) 103.27,79.83 104.46,79.83 104.57,79.71 104.57,79.5 104.46,79.38 104.16,79.38 104.04,79.27 104.04,79.04 104.16,78.93 104.46,78.93 104.57,78.81 104.57,78.58 104.46,78.47 104.16,78.47 104.04,78.35 104.04,78.13 104.16,78.01 104.46,78.01 104.57,77.9 104.57,77.67 104.46,77.55 104.16,77.55 104.04,77.44 104.04,77.21 104.16,77.1 104.46,77.1 104.57,76.98 104.57,76.75 104.46,76.64 104.16,76.64 104.04,76.52 104.04,76.3 104.16,76.18 104.87,76.18 105.03,76.33 105.03,79.71 105.14,79.83 105.8,79.83 106.57,79.05 110.9,79.05 112.45,77.51 112.45,61.63 114.88,59.19 114.88,56.92 114.65,56.68 112.6,56.68 112.45,56.54 112.45,56.02 112.3,55.87 110.65,55.87 109.85,55.07 108.69,55.07 108.28,54.67 v1(108.04,54.67)
  BOTTOM w0.14: v1(102.86,80.24) 103.2,79.9 U21.AY5 ; v1(108.04,54.67) 108.07,54.67 U27.F8
M_B_DQ53: length 51.6
  IN1 w0.102: v1(103.54,80.24) 106.02,80.24 106.49,79.78 106.89,79.78 107.01,79.66 107.01,79.48 107.12,79.37 107.35,79.37 107.46,79.48 107.46,79.66 107.58,79.78 107.81,79.78 107.92,79.66 107.92,79.48 108.03,79.37 108.26,79.37 108.38,79.48 108.38,79.66 108.49,79.78 108.72,79.78 108.83,79.66 108.83,79.48 108.95,79.37 109.18,79.37 109.29,79.48 109.29,79.66 109.41,79.78 109.63,79.78 109.75,79.66 109.75,79.48 109.86,79.37 110.09,79.37 110.21,79.48 110.21,79.66 110.32,79.78 110.59,79.78 112.74,77.63 112.74,76.97 112.85,76.86 113.51,76.86 113.64,76.73 113.64,76.53 113.51,76.4 112.85,76.4 112.74,76.29 112.74,76.06 112.85,75.94 113.9,75.94 114.03,75.82 114.03,75.61 113.9,75.49 112.85,75.49 112.74,75.37 112.74,75.14 112.85,75.03 113.9,75.03 114.03,74.9 114.03,74.7 113.9,74.57 112.85,74.57 112.74,74.46 112.74,74.23 112.85,74.12 113.9,74.12 114.03,73.99 114.03,73.79 113.9,73.66 112.85,73.66 112.74,73.54 112.74,73.32 112.85,73.2 113.9,73.2 114.03,73.07 114.03,72.87 113.9,72.74 112.85,72.74 112.74,72.63 112.74,72.4 112.85,72.29 113.9,72.29 114.03,72.16 114.03,71.96 113.9,71.83 112.85,71.83 112.74,71.72 112.74,61.75 115.17,59.31 115.17,56.32 114.73,55.87 113.25,55.87 v1(112.84,55.47)
  BOTTOM w0.14: U21.AV5 103.2,80.55 103.51,80.24 v1(103.54,80.24) ; v1(112.84,55.47) U27.E3
M_B_DQ54: length 50.5
  IN1 w0.102: v1(112.84,53.07) 112.84,53.27 113.04,53.47 115.28,53.47 117,55.2 117,60.66 116.89,60.78 116.3,60.78 116.17,60.9 116.17,61.11 116.3,61.23 116.89,61.23 117,61.35 117,61.58 116.89,61.69 115.98,61.69 115.85,61.82 115.85,62.02 115.98,62.15 116.89,62.15 117,62.26 117,62.49 116.89,62.61 115.98,62.61 115.85,62.73 115.85,62.94 115.98,63.06 116.68,63.06 116.81,63.19 116.81,63.39 116.68,63.52 115.98,63.52 115.85,63.65 115.85,77.14 111.3,81.69 104.99,81.69 104.76,81.92 102.52,81.92 102.14,81.54 v1(102.14,81.27)
  BOTTOM w0.14: U27.G2 113.26,53.48 v1(112.84,53.07) ; U21.AV6 102.49,80.92 v1(102.14,81.27)
M_B_DQ55: length 51.5
  IN1 w0.102: v1(108.04,52.25) 108.29,52.25 108.69,52.66 114.88,52.66 117.3,55.08 117.3,63.32 116.15,64.47 116.15,77.26 111.42,81.98 105.01,81.98 104.85,82.14 102.42,82.14 101.44,81.16 v1(101.4,81.16)
  BOTTOM w0.14: U27.H8 108.04,52.27 v1(108.04,52.25) ; U21.AV7 101.78,80.78 v1(101.4,81.16)
