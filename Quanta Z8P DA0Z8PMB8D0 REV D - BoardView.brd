# Allegro board Quanta Z8P DA0Z8PMB8D0 REV D - BoardView.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+5V on BOTTOM (solid shape): 199.83,28.4 199.83,27.93 199.81,27.88 199.79,27.84 199.78,27.74 199.79,27.65 199.8,27.63 199.78,27.59 199.66,27.46 199.66,24.45 199.12,23.91 199.12,22.97 198.63,22.48 197.42,22.48 197.25,22.65 197.25,23.83 197.3,23.91 197.39,23.92 197.65,23.89 197.86,24.03 197.94,24.26 197.87,24.48 197.86,24.51 197.86,24.54 197.87,24.56 197.91,24.59 197.91,26.18 198.02,26.29 198.02,28.55 198.03,28.58 198.59,28.58 199.66,28.58
+5V on IN1 (solid shape): outline of 994 points within 138.94,28.79 147.23,52.53
+5V on IN2 (solid shape): outline of 5798 points within 23,19.62 233.17,77.46
+5V_FAN1 on TOP (solid shape): 215.18,31.7 216.6,31.7 217.41,30.89 217.41,30.64 217.23,30.46 214.97,30.46 214.57,30.87 214.57,31.81 214.58,31.84 214.62,31.86 215.02,31.86
+5V_FAN1 on BOTTOM (solid shape): 222.31,36.02 222.31,35.44 222.3,35.43 222.3,33.62 221.35,32.67 221.32,32.67 220.89,32.24 219.11,32.24 218.47,31.59 216.95,30.71 215.91,30.71 215.71,30.92 215.71,31.55 216.19,32.03 216.19,32.47 217.26,32.47 217.27,32.42 217.28,32.36 217.3,32.31 217.33,32.27 217.37,32.22 217.41,32.19 217.45,32.15 217.5,32.13 217.56,32.11 217.61,32.11 217.67,32.11 217.72,32.11 217.78,32.13 217.83,32.15 217.88,32.19 217.92,32.22 217.95,32.27 217.98,32.31 218,32.36 218.02,32.42 218.02,32.47 218.02,32.53 218.01,32.58 217.99,32.64 217.97,32.69 217.94,32.73 217.9,32.77 217.85,32.81 217.8,32.83 217.75,32.85 217.7,32.87 217.64,32.87 217.59,32.87 217.53,32.85 217.48,32.83 217.43,32.81 217.39,32.77 217.35,32.73 217.32,32.69 217.29,32.64 217.27,32.58 217.26,32.53 217.26,32.47 216.19,32.47 216.19,33.3 217.19,34.31 219.1,34.31 220.15,35.36 221.98,36.35
+5V_KB on TOP (solid shape): 229.86,17.92 229.86,16.67 229.82,16.63 229.82,14.8 229.64,14.62 228.92,14.62 228.53,14.23 227.72,14.23 227.65,14.31 227.65,16.34 227.24,16.74 227.24,17.33 227.32,17.4 227.95,17.4 228.56,18.01 229.76,18.01
+5V_KB on BOTTOM (solid shape): 230.82,15.07 230.82,12.71 230.57,12.45 227.32,12.45 227.09,12.68 227.06,12.76 227.11,12.83 227.26,13.03 227.26,13.28 227.27,13.38 227.36,13.42 228.52,13.42 228.52,14.28 227.18,14.28 227.18,13.52 227.15,13.48 227.1,13.48 227.04,13.51 227.02,13.53 227.01,13.56 227.01,14.85 227.02,14.88 227.17,15.03 227.21,15.22 227.23,15.26 227.27,15.27 230.62,15.27
+5V_ODD on TOP (solid shape): 144.71,23.83 144.71,23.01 143.99,22.29 143.85,22.29 143.18,21.61 142.83,21.61 142.63,21.42 142.63,20.17 142.33,19.87 138.85,19.87 138.24,20.48 138.24,21.16 141.69,21.16 141.69,21.14 141.7,21.08 141.72,21.03 141.74,20.98 141.77,20.93 141.81,20.89 141.85,20.85 141.9,20.82 141.95,20.8 142,20.79 142.06,20.78 142.12,20.78 142.17,20.79 142.22,20.81 142.27,20.84 142.32,20.87 142.36,20.91 142.39,20.95 142.42,21 142.44,21.05 142.45,21.11 142.46,21.16 142.45,21.22 142.44,21.27 142.42,21.33 142.39,21.37 142.36,21.42 142.32,21.46 142.27,21.49 142.22,21.52 142.17,21.53 142.12,21.54 142.06,21.55 142,21.54 141.95,21.53 141.9,21.5 141.85,21.47 141.81,21.44 141.77,21.4 141.74,21.35 141.72,21.3 141.7,21.25 141.69,21.19 141.69,21.16 138.24,21.16 138.24,21.93 138.95,22.64 139.7,22.64 140.19,23.12 142.03,23.12 142.3,23.4 142.3,24.38 142.47,24.54 144,24.54
+5V_ODD on BOTTOM (solid shape): 112.65,32.84 112.85,32.84 113.82,32.84 113.84,32.83 113.84,32.65 113.83,32.64 112.09,32.64 111.86,32.86 111.86,33.05 112.12,33.3 112.19,33.3
+5V_ODD on BOTTOM (solid shape): 140.09,21.37 140.09,20.86 139.6,20.37 139.6,19.52 139.3,19.52 139.3,20.29 139.1,20.29 139.1,19.52 138.8,19.52 138.8,20.29 138.6,20.29 138.6,19.52 138.3,19.52 138.3,20.29 138.1,20.29 138.1,19.52 137.8,19.52 137.8,20.29 137.6,20.29 137.6,19.52 137.3,19.52 137.3,20.29 137.1,20.29 137.1,19.52 136.8,19.52 136.8,20.29 136.6,20.29 136.6,19.65 136.3,19.65 136.3,20.49 136.51,20.71 137.65,20.71 138.47,21.52 139.94,21.52
+5V_ODD on BOTTOM (solid shape): 144.13,29.01 144.15,29 144.16,28.99 144.42,28.86 144.7,28.95 144.71,28.95 144.73,28.96 144.73,26.99 144.81,26.91 144.88,26.74 145.03,26.63 145.04,26.62 145.05,26.6 145.05,23.58 145.06,23.58 145.06,21.63 144.96,21.54 144.88,21.53 144.82,21.52 144.47,21.52 144.46,21.52 144.31,21.55 144.16,21.52 144.15,21.52 143.14,21.52 143.05,21.53 142.97,21.53 142.95,21.54 142.93,21.55 142.83,21.64 142.83,23.15 142.38,23.6 142.38,25.02 142.39,25.04 142.41,25.05 142.62,25.39 142.41,25.73 142.39,25.74 142.38,25.76 142.38,28.19 143.2,29.01
+5V_PVDD on TOP (solid shape): 199.26,33.03 199.55,32.94 199.85,33.03 200.27,33.03 200.47,32.82 200.47,32.31 200.21,32.06 199.93,32.06 199.86,32.1 199.79,32.13 199.64,32.13 199.5,32.07 199.48,32.06 199.4,32.06 199.27,31.93 199.27,30.9 199.26,30.87 199.23,30.85 198.58,30.85 198.18,31.25 198.18,32.87 198.33,33.03
+5V_PVDD on BOTTOM (solid shape): 200.37,32.78 200.37,32.21 200.34,32.19 199.55,32.19 199.33,31.96 199.33,30.89 199.44,30.78 199.58,30.78 199.73,30.75 199.87,30.77 199.88,30.78 201.55,30.78 201.84,31.07 202.55,31.07 202.68,30.94 202.68,30.71 202.55,30.59 202.55,29.22 202.37,29.04 198.89,29.04 198.86,29.05 198.84,29.09 198.84,32.7 199.06,32.92 200.23,32.92
+5V_S5 on TOP (solid shape): 60.76,114.55 60.76,113.09 59.28,111.6 58.35,111.6 58.19,111.77 58.19,112.4 58.38,112.6 58.78,112.6 59.45,113.27 59.45,114.29 59.86,114.69 60.62,114.69
+5V_S5 on TOP (solid shape): 227.37,16.26 227.37,14.46 227.14,14.23 226.87,14.23 226.8,14.16 226.78,14.16 226.62,14.09 226.56,13.94 226.56,13.92 226.26,13.62 225.08,13.62 225.05,13.61 225.02,13.6 225,13.62 224.22,13.62 223.99,13.85 223.99,14.48 224.81,15.31 224.81,16.02 225.23,16.44 227.19,16.44
+5V_S5 on TOP (solid shape): 24.8,59.11 24.84,59.1 24.85,59.07 25.14,58.76 25.54,58.9 25.54,58.91 25.59,58.93 25.98,58.93 26.9,58.01 26.9,57.86 26.63,57.58 26.49,57.58 26.45,57.6 26.44,57.63 26.44,57.68 25.47,57.68 25.47,56.66 25.23,56.42 23.66,56.42 23.49,56.6 23.49,57.48 23.8,57.8 23.8,58.56 23.97,58.73 24.35,58.73 24.44,58.82 24.45,58.82 24.75,59.11
+5V_S5 on TOP (solid shape): outline of 161 points within 28.9,88.1 40.23,99.08
+5V_S5 on BOTTOM (solid shape): 48.14,39.68 48.14,38.69 47.56,38.11 47.56,34.85 47.1,34.4 44.99,34.4 44.72,34.68 44.72,39.17 45.63,40.09 47.74,40.09
+5V_S5 on BOTTOM (solid shape): 142.22,55 143.28,55 143.33,55.05 143.33,55.05 143.63,55.35 143.92,55.35 143.92,54.48 144.12,54.48 144.12,55.35 144.32,55.35 144.32,54.48 144.32,54.48 144.32,54.06 144.11,53.84 144.11,51.91 144.17,51.85 144.17,51.42 144.25,51.34 144.25,51.31 144.49,51.07 144.49,50.08 144.02,49.61 143.89,49.61 143.68,49.4 141.41,49.4 140.73,50.08 140.73,50.42 140.78,50.47 140.78,50.86 140.23,51.41 140.23,55.06 140.63,55.46 141.77,55.46
+5V_S5 on SVCC (solid shape): 37.98,88.95 37.98,84.82 27.85,74.68 27.73,74.52 27.7,74.32 27.7,71.41 27.52,71.08 27.7,70.76 27.7,58.98 27.37,58.6 27.7,58.22 27.7,50.4 27.73,50.21 27.85,50.04 33.28,44.6 33.45,44.49 33.65,44.45 35.89,44.45 40.6,39.75 40.76,39.64 40.96,39.6 111.39,39.6 111.58,39.64 111.75,39.75 122.22,50.22 127.69,50.22 128.51,49.4 128.51,45.07 116.79,33.36 38.96,33.36 38.61,33.58 38.27,33.36 27.88,33.36 24.15,37.09 24.05,37.25 23.9,37.34 19.47,41.77 19.47,52.31 19.76,52.68 19.47,53.06 19.47,79.68 30.83,91.03 30.89,91.07 30.94,91.11 35.82,91.11
+5V_S5 on IN2 (solid shape): outline of 3683 points within 125.32,12.33 228.72,51.97
+5V_S5 on IN3 (solid shape): 59.66,112.14 59.66,111.11 58.72,110.17 57.58,110.17 57.3,110.46 57.3,111.08 58.62,112.4 59.4,112.4
+5V_S5 on IN3 (solid shape): 41.2,101.17 41.2,99.34 41.19,99.3 41.18,99.29 41.04,99.03 41.13,98.76 41.14,98.73 41.14,98.7 41.13,98.68 40.81,98.35 38.76,98.35 38.53,98.59 38.53,101.08 39.21,101.76 40.61,101.76
+5VPCU on BOTTOM (solid shape): 141.87,65.21 145.88,65.21 146.28,65.61 148.8,65.61 149.68,64.73 149.68,63.1 149.68,61.43 149.68,58.29 149.68,57.44 149.18,56.95 147.15,56.95 146.89,56.69 146.86,56.68 146.84,56.68 146.64,56.68 146.45,56.6 146.17,56.6 146.13,56.61 146.12,56.65 146.12,57.44 145.92,57.44 145.92,56.65 145.9,56.61 145.87,56.6 145.78,56.6 145.72,56.66 145.72,58.05 147.17,59.49 147.17,61.43 147.12,61.47 147.12,61.67 146.88,61.92 146.88,63.1 146.57,63.41 146.18,63.41 145.99,63.22 145.99,62.22 145.86,62.09 145,62.09 144.81,62.28 144.81,62.58 144.84,62.62 144.85,62.63 144.91,63.24 144.31,63.11 144.3,63.1 143.99,62.79 143.99,59.2 144.16,59.04 144.16,58.38 144.08,58.15 144.16,57.92 144.16,57.71 144.32,57.55 144.32,56.62 144.12,56.62 144.12,57.44 143.92,57.44 143.92,56.62 143.59,56.62 143.56,56.65 143.52,56.68 143.23,56.97 141.79,56.97 141.2,57.55 141.22,57.59 141.54,58.42 141.68,59.3 141.68,59.83 141.6,60.36 141.45,60.92 141.22,61.45 141.02,61.79 140.79,62.11 140.78,62.13 140.78,62.41 140.79,62.42 140.79,65.13 141.26,65.61 141.48,65.61
+5VPCU on IN2 (solid shape): outline of 265 points within 140.35,60.51 149.01,65.99
+5VPCU_SRC on BOTTOM (solid shape): 145,71.47 145,68.29 146.15,67.14 146.15,66.21 145.67,65.73 141.21,65.73 141.19,65.72 141.17,65.72 140.45,65.72 139.12,64.39 136.81,64.39 136.59,64.6 136.59,72 136.6,72.01 136.6,73.99 136.93,74.32 142.15,74.32
+12V_PANEL on TOP (solid shape): 51.87,115.38 51.87,113.03 51.36,112.53 51.36,111.5 50.31,110.44 49.95,110.44 49.66,110.73 49.66,115.17 49.98,115.49 50,115.5 50.02,115.51 51.75,115.51
+12V_PANEL on BOTTOM (solid shape): outline of 123 points within 48.6,104.22 53.85,115.23
+VCC_1.05V_INT on BOTTOM (solid shape): 118.71,88.22 119.87,88.22 120.04,88.04 120.04,87.88 120.04,86.81 120.04,86.34 119.84,86.14 118.43,86.14 116.62,87.95 116.62,89.12 116.79,89.29 117.64,89.29
+VCC_1.05V_INT on IN2 (solid shape): outline of 2095 points within 95.63,86.97 121.76,97.67
+VCC_1.05V_IO on TOP (solid shape): 120.25,91.99 120.25,90.73 119.85,90.33 119.25,90.33 119.1,90.18 119.05,90.12 118.25,90.12 117.74,90.63 117.74,92.14 117.96,92.37 119.87,92.37
+VCC_1.05V_IO on TOP (solid shape): outline of 252 points within 92.92,87.66 97.93,94.32
+VCC_1.05V_IO on BOTTOM (solid shape): 120.03,91.81 120.03,88.59 119.88,88.44 118.98,88.44 117.33,90.09 117.33,92.18 117.57,92.43 119.41,92.43
+VCC_1.05V_IO on BOTTOM (solid shape): outline of 153 points within 93.17,86.6 96.68,90.62
+VCC_1.05V_IO on SVCC (solid shape): outline of 334 points within 92.82,83.39 119.11,94.57
+VCC_1.05V_IO on IN3 (solid shape): outline of 1081 points within 93.25,87.41 120.47,100.04
+VCC_1.8V on TOP (solid shape): 85.4,88.08 85.4,87.75 85.29,87.65 84.71,87.65 84.45,87.38 84.45,86.97 84.34,86.86 81.47,86.86 81.37,86.96 80.85,86.96 80.77,87.04 80.77,87.56 80.81,87.64 80.83,87.74 80.83,87.76 80.86,87.79 81.43,87.79 81.44,87.75 81.76,87.41 82.14,87.67 82.15,87.69 82.18,87.71 82.99,87.71 83.51,87.71 83.55,87.71 83.65,87.8 83.65,87.98 83.85,88.18 84.13,88.18 85.3,88.18
+VCC_1.8V on TOP (solid shape): 68.31,84.33 68.31,83.75 68.31,83.73 68.29,83.72 68.18,83.55 68.17,83.36 68.2,83.26 68.26,83.18 68.27,83.15 68.27,83.12 68.26,83.1 67.66,82.5 65.4,82.5 65.34,82.56 65.34,83.42 65.95,84.04 65.95,84.1 66.01,84.16 66.05,84.17 66.09,84.16 66.1,84.15 66.1,84.13 66.14,84.03 66.2,83.95 66.6,83.86 66.85,84.19 66.84,84.33 66.77,84.45 66.76,84.56 66.85,84.62 68.03,84.62
+VCC_1.8V on BOTTOM (solid shape): 84.2,88.15 84.34,88.15 84.5,87.99 84.63,87.99 84.69,87.98 84.75,87.99 84.85,87.99 85.01,88.15 85.15,88.15 85.53,87.77 85.55,87.77 85.68,87.64 85.68,86.7 85.67,86.68 85.63,86.63 85.55,86.55 83.64,86.55 83.52,86.67 83.52,87.06 83.26,87.31 83.26,88.2 83.52,88.45 83.9,88.45
+VCC_1.8V on IN1 (solid shape): outline of 1597 points within 66.66,82.78 93.58,88.04
+VCC_1.24V_AUD_ISH_PLL on TOP (solid shape): 94.91,85.74 94.91,85.54 95.15,85.3 95.63,85.3 95.68,85.34 96.07,85.34 96.16,85.25 96.16,84.77 96.09,84.7 95.43,84.7 95.43,84.7 94.42,84.7 94.27,84.85 94.27,85.13 94.37,85.23 94.37,85.72 94.46,85.81 94.84,85.81
+VCC_1.24V_AUD_ISH_PLL on BOTTOM (solid shape): 113.62,84.9 113.62,83.96 113.47,83.81 110.86,83.81 110.42,84.25 110.42,85.12 110.61,85.31 113.2,85.31
+VCC_1.24V_AUD_ISH_PLL on BOTTOM (solid shape): 95.14,85.33 95.15,85.33 95.18,85.31 95.48,85.31 95.67,85.5 95.76,85.5 95.86,85.4 95.86,85.17 95.58,84.9 95.58,84.89 95.39,84.7 95.2,84.7 94.97,84.47 94.87,84.47 94.67,84.68 94.54,84.68 94.34,84.88 94.34,85.03 94.85,85.54 94.93,85.54
+VCC_1.24V_AUD_ISH_PLL on IN3 (solid shape): outline of 1114 points within 93.96,81.18 113.92,85.72
+VCC_1.24V_DSI_CSI on TOP (solid shape): 97.63,87.45 97.63,87.05 97.52,86.95 96.45,86.95 96.3,87.09 96.3,87.5 96.12,87.68 95.98,87.68 95.86,87.8 95.86,88.1 95.96,88.2 96.88,88.2
+VCC_1.24V_DSI_CSI on TOP (solid shape): 125.92,88.27 125.92,86.53 125.82,86.43 124.7,86.43 124.49,86.63 124.49,88.27 124.85,88.63 125.56,88.63
+VCC_1.24V_DSI_CSI on BOTTOM (solid shape): 125.71,87.79 125.71,86.61 125.57,86.47 124.62,86.47 124.48,86.61 124.48,87.76 124.71,87.99 125.51,87.99
+VCC_1.24V_DSI_CSI on BOTTOM (solid shape): 96.81,88.32 96.86,88.27 96.91,88.22 97.03,88.11 97.03,87.78 96.95,87.7 96.75,87.7 96.69,87.76 96.62,87.76 96.61,87.77 96.5,87.79 96.39,87.77 96.38,87.76 96.36,87.76 96.29,87.7 96.01,87.7 95.63,88.08 95.6,88.12 95.55,88.16 95.54,88.19 95.55,88.25 95.69,88.41 95.87,88.3 95.88,88.27 95.95,88.2 96.26,88.2 96.33,88.27 96.34,88.3 96.39,88.38 96.48,88.41 96.53,88.42 96.55,88.44 96.7,88.44
+VCC_1.24V_DSI_CSI on IN2 (solid shape): outline of 1076 points within 93.75,85.29 125.95,91.5
+VCC_1.24V_GLM on TOP (solid shape): 96.39,84.41 96.39,84.18 95.98,83.77 95.98,83.24 95.91,83.17 95.3,83.17 95.14,83.33 95.14,83.59 94.99,83.74 94.68,83.74 94.68,83.74 94.33,83.74 94.2,83.87 94.2,84.52 94.27,84.59 96.22,84.59
+VCC_1.24V_GLM on TOP (solid shape): 89.64,84.41 89.77,84.41 90.06,84.12 90.07,84.11 90.07,84.09 90.07,83.72 89.89,83.53 89.48,83.53 89.37,83.64 89.36,83.67 89.36,83.76 89.16,83.96 88.11,83.96 87.96,84.12 87.96,84.35 88.11,84.5 89.56,84.5
+VCC_1.24V_GLM on BOTTOM (solid shape): 113.46,83.43 113.46,82.43 112.94,81.91 111.8,81.91 111.27,82.44 111.27,83.48 111.28,83.49 113.41,83.49
+VCC_1.24V_GLM on BOTTOM (solid shape): 96.27,84.45 96.27,84.14 95.89,83.76 95.48,83.76 95.12,84.12 95.12,84.37 95.24,84.49 95.36,84.49 95.71,84.83 95.89,84.83
+VCC_1.24V_GLM on IN2 (solid shape): outline of 765 points within 91.64,80.74 114.27,84.71
+VCC_1.24V_MPHY on TOP (solid shape): 124.37,88.38 124.37,86.7 124.16,86.49 123.27,86.49 123.07,86.69 123.07,88.54 123.25,88.73 124.01,88.73
+VCC_1.24V_MPHY on TOP (solid shape): 95.62,88.85 95.64,88.85 95.65,88.83 95.7,88.78 95.7,88.34 95.74,88.3 95.74,87.86 95.49,87.62 95.37,87.62 95.21,87.46 95.21,86.83 95.08,86.7 94.38,86.7 94.23,86.56 94.23,86.41 93.85,86.03 93.42,86.03 93.34,86.11 93.34,86.52 93.73,86.92 93.73,87.45 93.82,87.53 93.89,87.56 94.42,87.56 94.43,87.56 94.54,87.54 94.64,87.56 94.65,87.56 94.74,87.56 94.74,87.57 94.78,87.57 94.91,87.7 94.91,87.74 94.95,87.78 94.95,88.16 94.96,88.18 94.97,88.2 95.07,88.3 95.07,88.66 95.26,88.85
+VCC_1.24V_MPHY on BOTTOM (solid shape): 124.32,87.9 124.32,86.63 124.19,86.5 123.26,86.5 123.12,86.64 123.12,87.91 123.28,88.07 124.15,88.07
+VCC_1.24V_MPHY on BOTTOM (solid shape): 95.53,88 95.53,87.75 95.43,87.65 95.43,87.37 95.74,87.06 96.6,87.06 96.73,86.93 96.73,86.74 96.55,86.56 95.45,86.56 95.17,86.28 95.17,86.04 95.15,86.02 95.1,85.98 95.05,85.93 95.03,85.92 95.01,85.91 94.82,85.91 94.76,85.98 94.76,87.18 94.82,87.24 95.01,87.24 95.12,87.34 95.2,87.44 95.2,87.65 95.07,87.78 95.07,88 95.15,88.08 95.45,88.08
+VCC_1.24V_MPHY on IN2 (solid shape): outline of 633 points within 94.04,82.6 124.37,88.11
+VCC_1.24V_USB2 on TOP (solid shape): 95.95,86.49 95.95,86.21 96.06,86.11 96.06,86.09 96.12,85.98 96.23,85.92 96.25,85.92 96.34,85.83 96.34,85.59 96.24,85.48 95.2,85.48 95.05,85.63 95.05,86.38 95.27,86.6 95.44,86.6 95.46,86.61 95.83,86.61
+VCC_1.24V_USB2 on IN2 (solid shape): outline of 577 points within 95.11,83.15 114.23,86.09
+VCC_3.3V on TOP (solid shape): 85.59,90.37 85.59,89.7 85.37,89.48 85.37,89.1 85.52,88.96 85.91,88.96 85.99,88.87 85.99,88.39 85.94,88.33 84.9,88.33 84.7,88.53 84.7,89.14 84,89.83 84,90.33 84.1,90.43 85.53,90.43
+VCC_3.3V on TOP (solid shape): 65.83,84.85 65.83,84.09 65.21,83.47 65.21,82.35 65,82.13 64.98,82.12 64.96,82.12 64.87,82.12 64.68,81.94 64.65,81.9 64.61,81.88 63.8,81.88 63.64,82.05 63.64,84.16 63.74,84.26 64.17,84.37 64.2,84.82 64.19,84.9 64.25,84.96 64.33,85.01 64.38,85.09 64.38,85.11 64.41,85.13 65.55,85.13
+VCC_3.3V on BOTTOM (solid shape): 84.72,89.9 84.74,89.9 84.91,89.72 84.92,89.72 85.19,89.45 85.19,88.92 85.22,88.88 85.23,88.87 85.29,88.78 85.37,88.72 85.38,88.72 86.33,87.77 86.34,87.76 86.38,87.68 86.45,87.61 86.46,87.59 86.46,87.57 86.46,87.44 86.39,87.36 86.12,87.36 85.15,88.33 85.12,88.33 84.02,89.43 83.97,89.43 83.7,89.7 83.7,89.72 83.7,89.82 83.82,89.95 84.67,89.95
+VCC_3.3V on IN1 (solid shape): outline of 927 points within 63.91,83.98 87,90.53
+VCC_3.3V on IN2 (solid shape): outline of 1068 points within 84.65,84.72 93.79,93.09
+VCC_VCCGI on TOP (solid shape): 99.46,124.47 99.48,124.46 99.5,124.45 101.64,122.31 102.37,121.57 102.37,120.83 102.86,120.35 107.05,120.35 107.43,119.97 107.43,115.4 106.86,114.83 91.22,114.83 89.97,113.58 88.81,113.58 88.71,113.68 88.71,124.11 88.71,124.13 88.72,124.15 89.07,124.47
+VCC_VCCGI on TOP (solid shape): 83.59,92.77 83.64,92.77 83.93,92.77 84.06,92.64 84.06,92.11 84.26,91.9 84.72,91.9 84.82,91.8 84.82,91.45 84.7,91.33 84.04,91.33 83.88,91.17 83.88,90.35 83.6,90.07 83.56,90.07 83.55,90.08 83.32,90.16 83.08,90.07 82.56,90.07 82.51,90.12 82.51,91.78 82.39,91.89 82.39,92.01 82.41,92.05 82.42,92.06 82.52,92.33 82.41,92.59 82.4,92.61 82.4,92.65 82.44,92.69 82.45,92.69 82.52,92.76 82.54,92.78 82.57,92.78 82.62,92.77 82.92,92.77 82.97,92.77 83.02,92.79 83.54,92.79
+VCC_VCCGI on TOP (solid shape): outline of 129 points within 87.13,83.62 92.61,91.9
+VCC_VCCGI on BOTTOM (solid shape): 94.22,122.71 94.22,120.86 94.35,120.73 94.86,120.73 94.98,120.86 94.98,122.23 95.11,122.36 97.32,122.36 99.33,120.35 107.05,120.35 107.43,119.97 107.43,112.88 107.2,112.66 88.92,112.66 88.68,112.89 88.68,124.03 88.96,124.31 92.62,124.31
+VCC_VCCGI on BOTTOM (solid shape): outline of 87 points within 82.37,85.91 88.85,91.75
+VCC_VCCGI on BOTTOM (solid shape): outline of 87 points within 89.23,83.75 92.03,90.62
+VCC_VCCGI on IN1 (solid shape): outline of 979 points within 80.43,92.89 91.43,96.53
+VCC_VCCGI on SVCC (solid shape): 116.19,115.44 116.19,95.54 115.85,95.2 111.53,95.2 111.28,95.3 111.04,95.2 110.48,95.2 110.28,95.17 110.12,95.06 109.63,94.57 106.67,94.57 106.41,94.5 106.23,94.32 103.22,94.32 102.53,95 102.44,95.06 102.34,95.08 96.26,95.08 96.16,95.06 96.07,95 92.39,91.32 92.33,91.23 92.31,91.13 92.31,83.24 92.16,83.09 92.03,83.07 91.91,83.01 88.86,83.01 88.54,83.34 88.59,83.57 88.51,83.79 88.51,83.98 88.61,84.25 88.51,84.51 88.51,85.55 88.49,85.65 88.43,85.73 87.82,86.35 87.71,86.69 87.37,86.8 86.09,88.07 86.09,89.04 86.25,89.35 86.09,89.66 86.09,89.74 86.07,89.84 86.02,89.92 85.64,90.3 85.55,90.36 85.45,90.38 82.64,90.38 81.52,91.5 81.52,95.91 81.71,96.09 81.77,96.35 81.77,97.15 84.96,100.34 84.99,100.37 85.02,100.4 85.82,101.19 85.93,101.36 85.97,101.56 85.97,104.41 86.23,104.77 85.97,105.13 85.97,118.19 85.93,118.38 85.82,118.55 84.79,119.58 84.72,120.1 84.2,120.17 80.5,123.86 80.5,124.2 80.84,124.54 107.09,124.54
+VCC_VCCGI on IN3 (solid shape): outline of 2346 points within 83.07,84.7 105.9,118.83
+VDDQ_VTT on TOP (solid shape): outline of 137 points within 60.79,37.22 106.77,38.97
+VDDQ_VTT on BOTTOM (solid shape): 72.63,38.84 72.63,37.22 72.51,37.11 61.31,37.11 60.87,37.54 60.87,38.77 61.02,38.92 72.55,38.92
+VDDQ_VTT on BOTTOM (solid shape): 106.86,38.83 106.86,38.49 106.16,37.79 102.6,37.79 102.19,37.38 102.18,37.38 101.91,37.11 101.91,36.32 102.07,36.16 102.07,36.01 102.06,35.99 102.05,35.97 101.91,35.83 101.91,35.04 102.05,34.9 102.06,34.88 102.07,34.86 102.07,34.43 102.06,34.41 102.05,34.39 101.64,33.98 101.64,32.34 102.28,31.69 102.28,31.52 103.06,30.75 103.06,30.24 103.22,30.04 103.22,29.32 103.22,28.77 103.2,28.73 103.17,28.72 103.07,28.72 103.03,28.73 103.02,28.77 103.02,29.71 103.01,29.71 103.01,29.92 102.97,29.96 102.48,29.96 102.42,29.89 101.7,29.43 102.4,28.95 102.4,28.33 102.39,28.32 101.36,28.32 101.11,28.57 101.11,30.12 101.11,30.12 101.11,30.2 101.11,30.2 101.11,30.24 101.11,30.26 101.13,30.28 101.17,30.32 101.17,31.04 101.16,31.17 101.11,31.3 101.11,31.31 101.11,31.53 100.14,32.5 100.14,34.25 100.13,34.27 100.13,34.61 99.36,35.37 99.36,36.3 99.14,36.53 99.14,36.55 98.58,37.11 95.57,37.11 95.09,37.59 95.09,38.84 95.16,38.91 96.26,38.91 96.26,38.92 106.76,38.92
+VIN on TOP (solid shape): 55.08,25.83 55.08,23.18 54.79,22.89 51.46,22.89 51.07,23.28 51.07,25.68 51.63,26.24 54.66,26.24
+VIN on TOP (solid shape): 54.25,116.03 54.25,115.26 53.75,114.75 53.73,114.74 53.71,114.74 52.52,114.74 52.34,114.92 52.34,115.96 52.55,116.17 54.11,116.17
+VIN on TOP (solid shape): 217.97,39.73 217.97,39.48 219.59,37.86 219.59,36.05 219.26,35.72 219.26,32.77 219.16,32.67 217.99,32.67 217.97,32.68 217.96,32.69 217.9,32.77 217.82,32.82 217.58,32.87 217.37,32.76 217.34,32.73 217.31,32.72 217.27,32.73 217.03,32.97 217.03,34.63 216.62,35.03 216.62,39.65 216.9,39.93 217.77,39.93
+VIN on TOP (solid shape): outline of 1136 points within 120.1,81.13 136.3,135.87
+VIN on BOTTOM (solid shape): 110.39,133.46 110.39,130.89 109.5,130 107.5,130 106.91,130.6 106.91,133.45 107.05,133.58 110.27,133.58
+VIN on BOTTOM (solid shape): 73.75,129.73 73.75,127.99 73.46,127.71 69.25,127.71 68.65,128.31 68.65,129.79 68.97,130.11 73.37,130.11
+VIN on BOTTOM (solid shape): 75.09,30.47 75.09,26.6 74.8,26.3 73.9,26.3 73.2,27.01 71.99,27.01 71.79,27.21 71.79,30.67 72.07,30.95 74.61,30.95
+VIN on BOTTOM (solid shape): 121.49,134.54 121.49,134.21 121.82,133.88 122.79,133.88 122.98,133.69 122.98,130.06 122.83,129.92 121.11,129.92 120.79,130.23 120.79,134.55 120.96,134.73 121.3,134.73
+VIN on BOTTOM (solid shape): 86.42,126.25 90.58,126.25 90.84,125.99 90.84,124.74 90.61,124.52 85.77,124.52 84.81,125.47 84.81,126.7 85.07,126.97 85.7,126.97
+VIN on BOTTOM (solid shape): 54.9,27.56 54.9,26.82 54.77,26.69 54.77,24.82 54.47,24.52 54.47,23.3 53.59,22.42 50.12,22.42 49.8,22.74 49.8,25.55 51.17,26.92 51.17,26.92 51.89,27.64 54.82,27.64
+VIN on BOTTOM (solid shape): 137.4,85.25 137.4,81.23 137.4,81.23 137.4,79.26 137.78,78.88 137.78,76.97 137.35,76.54 133.79,76.54 133.51,76.82 133.51,82.2 133.54,82.23 133.54,82.89 134.56,83.91 134.56,84.14 135.85,85.43 137.22,85.43
+VIN on BOTTOM (solid shape): 93.01,33.96 93.01,30.1 93.01,30.1 93.01,28.99 92.84,28.83 90.62,28.83 90.37,29.08 90.37,29.62 90.37,29.64 90.38,29.66 90.49,29.92 90.38,30.18 90.37,30.2 90.37,30.21 90.37,33.13 90.37,33.15 90.38,33.17 91.5,34.28 92.69,34.28
+VIN on SVCC (solid shape): outline of 2464 points within 50.74,18.39 220.69,139.77
+VIN on IN2 (solid shape): outline of 9854 points within 50.6,81.16 137.28,139.77
GND on TOP (solid shape): 19.57,24.14 19.57,23.22 19.41,23.06 17.48,23.06 17.47,23.07 17.47,23.57 18.57,24.67 19.04,24.67
GND on TOP (solid shape): 30.46,37.68 30.46,33.32 30.4,33.26 26,33.26 25.91,33.35 25.91,37.7 25.99,37.79 30.35,37.79
GND on TOP (solid shape): 45.22,74.32 45.22,73.17 44.71,72.66 42.67,72.66 42.16,73.16 42.16,74.41 42.35,74.59 44.95,74.59
GND on TOP (solid shape): 104.4,28.33 104.4,26.87 104.27,26.75 102.78,26.75 102.6,26.92 102.6,28.35 102.8,28.54 104.18,28.54
GND on TOP (solid shape): 109.99,120.08 109.99,112.42 109.77,112.2 109.09,112.2 107.85,113.43 107.85,120.22 108.05,120.42 109.66,120.42
GND on TOP (solid shape): 115.95,125.02 115.95,121.56 115.88,121.49 112.43,121.49 112.38,121.54 112.38,125.02 112.44,125.09 115.89,125.09
GND on TOP (solid shape): 118.47,32.85 118.47,29.09 118.32,28.95 114.52,28.95 114.41,29.06 114.41,32.83 114.57,33 118.32,33
GND on TOP (solid shape): 128.66,108.44 128.66,106.05 128.59,105.99 127.2,105.99 127.09,106.1 127.09,108.4 127.24,108.55 128.55,108.55
GND on TOP (solid shape): 128.91,132.85 128.91,131.7 128.81,131.6 127.72,131.6 127.51,131.8 127.51,132.85 127.64,132.99 128.78,132.99
GND on TOP (solid shape): 143.06,82.43 143.06,81.35 142.91,81.21 141.85,81.21 141.76,81.3 141.76,82.5 141.9,82.64 142.85,82.64
GND on TOP (solid shape): 159.78,36.16 159.78,32.66 159.7,32.58 156.21,32.58 156.12,32.68 156.12,36.1 156.25,36.23 159.7,36.23
GND on TOP (solid shape): 204.16,28.87 204.16,24.44 204.11,24.39 199.65,24.39 199.57,24.47 199.57,28.81 199.72,28.96 204.06,28.96
GND on TOP (solid shape): 206.64,38.83 206.64,36.71 206.58,36.65 204.43,36.65 204.32,36.76 204.32,38.87 204.42,38.98 206.5,38.98
GND on TOP (solid shape): 232.79,15.19 232.79,14.31 232.6,14.12 231.05,14.12 230.91,14.26 230.91,15.19 231.11,15.39 232.59,15.39
GND on TOP (solid shape): 55.63,63.57 55.63,62.27 55.5,62.14 53.18,62.14 52.83,62.48 52.83,62.87 53.93,63.96 55.25,63.96
GND on TOP (solid shape): 47.94,114.24 47.94,113.23 47.54,112.83 47.54,110.54 47.32,110.32 45.98,110.32 45.84,110.47 45.84,113.39 46.76,114.31 47.88,114.31
GND on TOP (solid shape): 58.15,26.5 58.15,21.85 57.75,21.45 55.66,21.45 55.31,21.8 55.31,26.58 55.74,27.01 57.64,27.01
GND on TOP (solid shape): 63.26,82.71 63.26,81.06 62.8,80.6 60.66,80.6 60.23,81.03 60.23,81.77 60.41,81.95 61.63,81.95 62.47,82.78 63.18,82.78
GND on TOP (solid shape): 105.57,121.8 105.57,120.66 105.52,120.6 102.86,120.6 102.65,120.81 102.65,121.06 103.19,121.59 104.71,121.59 105.12,122 105.37,122
GND on TOP (solid shape): 124.51,38.8 124.51,37.19 124.47,37.15 124.47,35.39 123.89,34.81 121.35,34.81 120.23,35.93 120.23,38.89 120.43,39.09 124.21,39.09
GND on TOP (solid shape): 126.14,85.88 126.14,84.99 125.94,84.8 123.48,84.8 123.41,84.73 121.9,84.73 121.67,84.96 121.67,86.06 121.73,86.12 125.9,86.12
GND on TOP (solid shape): 28.78,90.42 28.78,90.02 28.77,90.02 28.77,88.2 28.78,88.19 28.78,87.88 28.55,87.66 26.98,87.66 26.87,87.76 26.87,90.37 26.98,90.48 28.72,90.48
GND on TOP (solid shape): 118.21,18.92 118.21,16.95 118.07,16.81 117.12,16.81 116.98,16.96 116.98,18 116.5,18.48 116.5,19.01 116.58,19.09 118.03,19.09
GND on TOP (solid shape): 56.69,109.13 56.69,108 56.38,107.69 51.58,107.69 51.22,108.06 50.43,108.06 50.23,108.26 50.23,108.69 50.84,109.31 56.51,109.31
GND on TOP (solid shape): 34.48,34.68 37.48,34.68 37.69,34.88 37.83,34.88 37.96,34.75 37.96,34.12 37.78,33.94 34.78,33.94 34.44,34.28 33.91,34.28 33.55,34.64 33.55,34.92 33.63,35 34.16,35
GND on TOP (solid shape): 82.32,91.62 82.32,90.15 82.18,90.01 81.92,90.01 81.82,90.02 81.73,90.01 80.23,90.01 80.06,90.18 80.06,91.61 80.2,91.76 82.19,91.76
GND on TOP (solid shape): 23.66,58.44 23.66,57.83 23.36,57.53 23.36,56.9 22.9,56.43 22.88,56.42 22.86,56.42 21.88,56.42 21.71,56.59 21.71,56.96 21.72,56.97 21.72,57.39 22.88,58.55 23.56,58.55
GND on TOP (solid shape): 54.28,116.92 56.17,116.92 56.33,116.76 56.33,115.79 55.72,115.18 55.72,115.17 55.35,114.81 54.75,114.81 54.53,115.03 54.53,116.15 54.2,116.47 53.16,116.47 52.99,116.64 52.99,117.1 53.19,117.29 53.91,117.29
GND on TOP (solid shape): 88.33,124.11 88.33,117.84 88.38,117.78 88.38,113.53 88.22,113.38 86.77,113.38 86.77,113.39 86.05,113.39 82.74,116.69 82.74,122.26 83.17,122.69 85.99,122.69 86.65,123.35 86.65,123.83 87.34,124.52 87.92,124.52
GND on TOP (solid shape): 128.72,25.52 128.72,24.56 128.1,23.95 127.83,23.95 127.82,23.95 127.41,24.15 126.98,24.32 126.96,24.33 126.95,24.36 126.95,25.45 127.06,25.56 128.68,25.56
GND on TOP (solid shape): 44.31,21.05 44.31,18.94 44.23,18.85 43.93,18.85 43.84,18.75 43.84,17.83 43.83,17.82 43.57,17.82 43.56,17.83 43.56,18.67 43.56,18.78 43.53,18.8 42.13,18.8 42.12,18.82 42.12,20.95 42.3,21.13 44.23,21.13
GND on TOP (solid shape): 113.51,129.98 113.51,129.98 113.69,129.8 113.7,129.78 113.7,129.77 113.7,129.37 113.7,129.35 113.69,129.34 113.05,128.7 110.57,128.7 110.46,128.8 110.46,129.41 111.56,130.51 112.98,130.51
GND on TOP (solid shape): 31.63,74.09 31.68,74.03 31.74,73.98 31.81,73.91 31.81,72.97 31.56,72.72 31.56,71.22 31.42,71.08 30.72,71.08 30.69,71.1 30.69,72 30.61,72.08 30.28,72.08 30.15,72.21 30.15,72.53 29.86,72.82 29.86,73.22 30.74,74.11 31.62,74.11
GND on TOP (solid shape): 20.53,51.7 20.53,51.24 20.71,51.06 20.71,50.37 20.71,50.35 20.7,50.34 20.67,50.31 20.67,49.52 20.22,49.07 20.2,49.06 20.18,49.05 17.21,49.05 16.93,49.33 16.93,49.79 17.11,49.97 17.51,49.97 17.66,50.12 17.66,50.45 17.74,50.53 19.47,50.53 19.87,50.93 19.87,51.72 19.98,51.82 20.41,51.82
GND on TOP (solid shape): 208.24,33.89 208.45,33.89 208.54,33.8 208.54,32.86 208.25,32.57 205.03,32.57 204.85,32.75 204.85,32.88 204.97,33 205.33,33 205.63,32.96 205.86,33.15 205.86,33.15 205.94,33.23 205.94,33.79 206.03,33.89 208.24,33.89
GND on TOP (solid shape): 90.11,90.21 90.11,87.74 90,87.63 89.64,87.63 89.52,87.74 89.52,88.53 89.3,88.74 88.69,88.74 88.57,88.86 88.57,89.27 88.57,89.33 88.57,89.4 88.57,89.56 88.8,89.79 89.36,89.79 89.51,89.94 89.51,90 89.51,90.02 89.52,90.04 89.55,90.06 89.55,90.23 89.69,90.37 89.95,90.37
GND on TOP (solid shape): 63.66,30.72 63.66,25.41 64.22,24.84 64.22,20.63 64.04,20.45 62.7,20.45 62.44,20.2 60.21,20.2 60.12,20.29 60.12,22.6 60.01,22.71 59.14,22.71 59.04,22.81 59.04,24.29 60.12,25.37 60.12,31.13 60.44,31.45 62.93,31.45
GND on TOP (solid shape): 33.08,57.96 33.08,57.62 33.04,57.54 32.96,57.52 31.62,57.6 30.29,57.36 30.27,57.36 30.24,57.38 29.96,57.66 29.96,58.47 30.19,58.71 32.32,58.71
GND on TOP (solid shape): 213.28,23.89 213.32,23.9 213.35,23.89 214.12,23.11 214.12,22.49 214.15,22.46 214.15,22.39 214.44,22.1 214.44,20.63 213.73,19.91 213.7,19.9 213.66,19.91 213.4,20.18 213.4,20.97 213.31,21.05 213.3,21.09 213.31,21.12 213.32,21.13 213.32,22.36 213.08,22.61 213.08,23.69
GND on TOP (solid shape): 159.11,29.13 159.11,28.81 158.56,28.26 158.56,27.59 158.61,27.54 160.44,27.54 160.74,27.23 160.74,25.79 160.64,25.68 159.73,25.68 159.07,26.34 157.75,26.34 157.07,25.67 155.68,25.67 155.48,25.86 155.48,26.17 155.54,26.22 156.4,26.22 156.69,26.51 156.69,27.51 156.83,27.65 156.83,28.12 156.88,28.17 157.31,28.17 157.48,28.34 157.48,29.2 157.56,29.29 158.96,29.29
GND on TOP (solid shape): 52.17,128.38 52.21,128.37 52.22,128.33 52.22,127.47 52.45,127.47 52.45,128.33 52.46,128.37 52.5,128.38 52.67,128.38 52.71,128.37 52.72,128.33 52.72,127.47 52.73,127.47 52.8,127.4 52.81,127.39 52.82,127.34 52.86,127.34 52.89,127.31 54.63,127.31 55.07,126.87 55.07,125.67 54.92,125.51 51.35,125.51 51.05,125.81 51.05,128.22 51.21,128.38
GND on TOP (solid shape): 6.71,83.18 7.83,83.18 7.88,83.13 7.88,82.48 7.82,82.38 7.77,82.27 7.73,82.25 7.36,82.25 6.84,82.94 6.01,82.7 5.84,82.7 5.69,82.85 5.69,83.2 5.93,83.45 6.44,83.45
GND on TOP (solid shape): 47.84,58.91 47.84,55.25 47.9,55.19 47.9,55.07 49.72,53.25 49.84,53.25 49.97,53.12 50.19,53.12 50.23,53.1 50.24,53.1 50.44,52.96 50.68,52.9 50.69,52.9 51.13,52.46 51.13,51.87 51.03,51.78 50.18,51.78 49.65,51.24 49.64,51.2 49.46,50.64 49.18,50.12 47.83,48.77 45.49,48.77 43.7,50.56 43.7,52.97 46.11,55.38 46.11,58.86 46.26,59.01 47.74,59.01
GND on TOP (solid shape): 199.78,34.02 199.82,34 199.83,33.96 199.83,33.46 199.82,33.42 199.78,33.41 198.18,33.41 197.8,33.03 197.8,32.14 197.79,32.1 197.75,32.09 196.29,32.09 196.25,32.1 196.24,32.13 196.15,32.31 195.98,32.42 195.9,32.44 195.69,32.64 195.69,33.61 195.9,33.81 196.96,33.81 197.17,34.02
GND on TOP (solid shape): 50.38,58.88 50.38,56.1 50.36,56.06 50.29,55.99 50.24,55.91 50.21,55.87 50.19,55.82 50.16,55.72 50.15,55.63 50.16,55.44 50.22,55.27 50.23,55.24 50.22,55.21 50.18,55.17 49.81,55.17 49.73,55.26 49.48,55.36 49.24,55.27 49.22,55.25 49.18,55.26 48.93,55.5 48.93,58.91 49.03,59.01 50.25,59.01
GND on TOP (solid shape): 25.16,70.69 25.16,70.28 25.17,70.28 25.23,70.14 25.37,70.07 25.39,70.06 25.79,70.06 26.02,69.83 26.02,69.56 26.15,69.43 26.15,69.42 26.19,69.36 26.26,69.31 26.26,69.31 26.4,69.17 26.4,68.91 26.36,68.86 25.37,68.86 24.69,69.54 24.27,69.54 24.06,69.33 24.06,68.99 23.93,68.86 23.58,68.86 23.49,68.96 23.49,69.54 23.84,69.9 23.84,70.51 23.94,70.68 23.97,70.87 23.97,70.97 24.01,71.01 24.84,71.01
GND on TOP (solid shape): 102.4,109.74 102.4,106.66 100.84,105.1 100.69,105.1 100.66,105.11 100.64,105.13 100.29,105.36 99.94,105.13 99.92,105.11 99.89,105.1 99.85,105.1 99.82,105.11 99.8,105.13 99.53,105.35 99.19,105.25 99.12,105.22 99.05,105.25 98.09,106.21 97.75,106.21 97.57,106.4 97.57,109.51 98.28,110.22 101.92,110.22
GND on TOP (solid shape): 11.26,55.57 12.72,55.95 14.01,55.16 15.68,55.16 16.06,54.77 16.06,54.13 15.86,53.93 14.57,53.93 14.35,53.72 14.35,53.07 14.1,52.82 13.8,52.82 13.66,52.97 13.66,54.56 13.63,54.59 13.16,54.59 12.41,54.96 11.68,54.56 4.41,54.56 4.41,55.15 4.82,55.57
GND on TOP (solid shape): 11.12,61.93 11.12,61.44 11.44,59.27 9.6,58.09 2.02,58.09 2.02,55.57 2.63,55.57 2.63,54.56 1.01,54.56 1.01,59.1 9.6,59.1 10.53,59.72 10.32,60.81 10.32,62.02 10.45,62.15 10.9,62.15
GND on TOP (solid shape): 224.8,46.97 226.8,45 228.8,46.97 232.88,46.97 233.03,46.82 233.03,44.94 232.85,44.76 229.52,44.76 229.2,44.76 228.69,44.25 228.69,43.39 228.46,43.16 223.35,43.16 223.17,43.34 223.17,43.37 223.17,43.38 223.22,43.69 223.23,44 223.23,46.92 223.25,46.95 223.28,46.97
GND on TOP (solid shape): 31.61,67.14 31.61,63.45 31.47,63.31 27.95,63.31 27.88,63.35 27.85,63.42 27.85,63.58 27.81,63.73 27.85,63.98 27.81,64.23 27.85,64.48 27.81,64.73 27.84,64.86 27.85,65 27.84,65.12 27.81,65.23 27.84,65.35 27.85,65.47 27.84,65.6 27.81,65.73 27.83,65.79 27.84,65.85 27.85,66.04 27.81,66.23 27.85,66.42 27.84,66.61 27.83,66.67 27.81,66.73 27.85,66.89 27.85,67.06 27.95,67.16 31.59,67.16
GND on TOP (solid shape): 81.49,86.68 84.33,86.68 84.47,86.53 84.47,85.84 84.11,85.48 83,85.48 82.88,85.6 82.87,85.62 82.87,85.65 82.72,86.07 82.27,86.01 82.26,86 82.23,85.98 82.14,85.98 82.1,86 82.09,86.01 81.82,86.13 81.55,86 81.53,85.99 81.51,85.98 81.47,85.98 81.45,85.99 81.43,86.01 81.37,86.09 81.3,86.15 81.17,86.2 81,86.19 80.98,86.21 80.79,86.4 80.79,86.73 80.89,86.84 81.33,86.84
GND on TOP (solid shape): 228.05,20.1 228.05,17.84 227.93,17.71 227.3,17.71 227.27,17.74 227.27,18.78 226.58,19.46 224.85,19.46 224.06,18.67 222.62,18.67 222.59,18.7 222.59,19.33 222.89,19.49 223.19,19.67 223.65,20 224.08,20.39 224.18,20.41 224.25,20.33 224.59,20 224.99,20.26 224.94,20.6 224.64,20.77 224.55,20.82 224.56,20.92 224.61,20.99 224.63,21 224.65,21.01 227.14,21.01
GND on TOP (solid shape): 119.89,55.89 119.89,50.85 120.05,50.69 120.05,46.17 119.82,45.94 118.72,45.94 118.69,45.95 118.67,45.99 118.67,46.18 118.6,46.5 118.38,46.76 118.38,46.79 118.38,48.63 118.38,48.65 118.4,48.67 118.63,49.46 117.96,49.94 117.54,49.94 117.5,49.96 117.49,49.99 117.49,50.7 117.59,50.81 118.27,50.81 118.38,50.91 118.38,51.93 118.38,51.95 118.6,52.22 118.67,52.53 118.67,55.89 118.69,55.92 118.72,55.94 119.85,55.94
GND on TOP (solid shape): outline of 81 points within 131.34,65.62 147.2,79.95
GND on TOP (solid shape): outline of 92 points within 92.82,125.18 105.98,135.08
GND on TOP (solid shape): 133.72,54.76 134.2,54.8 134.68,54.76 134.69,54.76 135.52,54.76 137.16,53.12 137.16,49.52 137.11,49.47 137.1,49.44 137.07,49.37 137.03,49.31 136.97,49.26 136.88,49.22 136.85,49.21 136.4,48.76 131.59,48.76 130.6,49.75 130.6,50.78 130.64,50.86 130.73,50.88 131.22,51.24 130.73,51.61 130.64,51.63 130.6,51.71 130.6,53.19 131.69,54.28 131.76,54.31 131.83,54.28 132.25,54.19 132.54,54.5 132.59,54.56 132.67,54.57 132.93,54.58 133.13,54.74 133.15,54.75 133.17,54.76 133.71,54.76
GND on TOP (solid shape): outline of 108 points within 85.33,81.11 94.02,85.9
GND on TOP (solid shape): outline of 243 points within 153.7,40.94 159.63,46.54
GND on TOP (solid shape): 13.92,96.72 13.92,94.74 13.42,93.52 12.2,93.02 9.44,93.02 8.82,92.15 7.8,91.82 6,91.82 4.98,92.15 4.36,93.02 3.68,93.02 3.76,92.71 3.78,92.4 3.78,91.2 3.28,89.87 2.02,89.19 2.02,83.66 3.26,82.42 5.45,82.42 5.86,82 5.93,81.82 6.05,81.66 6.23,81.51 6.45,81.42 6.49,81.38 7.92,81.38 10.9,84.36 14.56,84.36 17.26,81.66 17.26,76.02 14.23,72.99 10.49,72.99 10.35,73.13 10.35,73.84 10.52,74.92 9.6,75.52 1.01,75.52 1.01,76.99 2.33,76.99 3.04,77.29 3.34,78 3.34,79.82 3.04,80.52 2.33,80.81 1.01,80.81 1.01,90.19 1.76,90.19 2.47,90.49 2.76,91.2 2.76,92.4 2.47,93.11 1.76,93.41 1.59,93.41 1.59,94.03 5.29,94.03 5.29,93.54 5.5,93.04 6,92.83 7.8,92.83 8.3,93.04 8.51,93.54 8.51,94.03 12.2,94.03 12.7,94.24 12.91,94.74 12.91,96.79 13.05,96.93 13.72,96.93
GND on TOP (solid shape): outline of 160 points within 95.35,81.54 103.93,89.05
GND on TOP (solid shape): outline of 567 points within 81.48,85.27 99.27,96.3
GND on TOP (solid shape): outline of 1388 points within 0.51,0.51 239.29,141.29
GND on BOTTOM (solid shape): 13.5,20.76 13.5,17.51 13.19,17.2 11.16,17.2 10.86,17.51 10.86,20.66 11.34,21.14 13.12,21.14
GND on BOTTOM (solid shape): 31.48,67.01 31.48,63.58 31.36,63.45 28.05,63.45 27.93,63.58 27.93,67.01 28.05,67.14 31.36,67.14
GND on BOTTOM (solid shape): 49.95,38.13 49.95,34.7 49.74,34.5 48.14,34.5 47.92,34.73 47.92,38.05 48.58,38.71 49.36,38.71
GND on BOTTOM (solid shape): 53.24,17.91 53.24,16.06 53.08,15.9 51.27,15.9 51.01,16.16 51.01,18 51.04,18.03 53.11,18.03
GND on BOTTOM (solid shape): 79.7,136.94 79.7,135.3 79.68,135.28 78.79,135.28 78.76,135.32 78.76,136.91 78.82,136.97 79.67,136.97
GND on BOTTOM (solid shape): 84.05,34.08 84.05,32.45 83.96,32.36 82.48,32.36 82.37,32.47 82.37,34.09 82.54,34.26 83.87,34.26
GND on BOTTOM (solid shape): 86.18,17.98 86.18,16.06 86.06,15.94 82.46,15.94 82.3,16.09 82.3,18.08 82.55,18.33 85.83,18.33
GND on BOTTOM (solid shape): 91.2,137.27 91.2,135.87 91.05,135.72 85.13,135.72 85.05,135.79 85.05,136.38 86.63,137.95 90.51,137.95
GND on BOTTOM (solid shape): 96.63,136.67 96.63,135.13 96.58,135.09 95.69,135.09 95.66,135.12 95.66,136.69 95.7,136.73 96.56,136.73
GND on BOTTOM (solid shape): 104.41,28.49 104.41,26.79 104.37,26.75 102.7,26.75 102.63,26.82 102.63,28.47 102.68,28.52 104.37,28.52
GND on BOTTOM (solid shape): 107.54,19.24 107.54,17.51 107.45,17.42 105.22,17.42 104.8,17.83 104.8,19.87 105.05,20.12 106.66,20.12
GND on BOTTOM (solid shape): 115.95,125.02 115.95,121.56 115.88,121.49 112.43,121.49 112.38,121.54 112.38,125.02 112.44,125.09 115.89,125.09
GND on BOTTOM (solid shape): 118.57,32.93 118.57,28.95 118.49,28.87 114.43,28.87 114.31,28.98 114.31,32.91 114.46,33.06 118.44,33.06
GND on BOTTOM (solid shape): 118.84,19 118.84,16.96 118.72,16.84 117.12,16.84 116.86,17.1 116.86,18.99 116.97,19.11 118.73,19.11
GND on BOTTOM (solid shape): 120.01,38.85 120.01,36.72 119.76,36.47 116.41,36.47 116.32,36.56 116.32,37.16 118.22,39.06 119.8,39.06
GND on BOTTOM (solid shape): 123.91,139.2 123.91,136.68 123.73,136.49 122.58,136.49 122.48,136.6 122.48,139.14 122.63,139.28 123.84,139.28
GND on BOTTOM (solid shape): 133.07,79.53 133.07,76.05 132.86,75.84 128.61,75.84 128.05,76.4 128.05,79.01 128.68,79.63 132.97,79.63
GND on BOTTOM (solid shape): 136.4,74.34 136.4,64.73 136.08,64.41 134.39,64.41 133.49,65.31 133.49,74.34 133.87,74.72 136.01,74.72
GND on BOTTOM (solid shape): 146.06,52.23 146.06,51.34 145.79,51.07 144.66,51.07 144.38,51.36 144.38,52.32 144.44,52.38 145.91,52.38
GND on BOTTOM (solid shape): 146.71,68.86 146.71,67.85 146.53,67.66 145.82,67.66 145.17,68.3 145.17,68.89 145.27,68.99 146.59,68.99
GND on BOTTOM (solid shape): 146.94,16.98 146.94,16.43 146.29,15.78 144.87,15.78 144.66,15.98 144.66,17.71 146.21,17.71
GND on BOTTOM (solid shape): 159.74,36.04 159.74,32.81 159.46,32.53 156.79,32.53 156.55,32.77 156.55,35.97 156.84,36.26 159.52,36.26
GND on BOTTOM (solid shape): 220.61,40.26 220.61,39.22 220.43,39.04 218.6,38 218.48,38.08 218.15,39.45 219.06,40.37 220.51,40.37
GND on BOTTOM (solid shape): 30.29,44.01 30.29,41.08 29.53,40.32 28.78,40.32 28.54,40.56 26.13,40.56 25.36,41.33 25.36,44.15 25.84,44.63 29.67,44.63
GND on BOTTOM (solid shape): 105.57,121.8 105.57,120.73 105.45,120.6 102.86,120.6 102.65,120.81 102.65,121.06 103.19,121.59 104.71,121.59 105.12,122 105.37,122
GND on BOTTOM (solid shape): 83.81,133.69 83.81,130.97 83.55,130.71 81.29,130.71 81.19,130.82 81.19,133.53 81.45,133.82 81.46,133.83 81.48,133.84 83.65,133.84
GND on BOTTOM (solid shape): 20.7,59.74 20.7,58.66 20.5,58.46 20.15,58.46 20.15,58.46 16.14,58.46 15.1,57.42 13.75,57.42 13.44,57.73 13.44,59.79 13.84,60.18 20.25,60.18
GND on BOTTOM (solid shape): 66.11,18.24 66.15,18.23 66.16,18.19 66.16,14.1 65.57,13.51 64.54,13.51 64.41,13.65 64.41,17.99 64.66,18.24
GND on BOTTOM (solid shape): 131.47,50.27 131.47,50.21 131.46,50.2 131.46,48.73 131.84,48.35 131.84,47.3 131.76,47.23 131.11,47.23 130.59,47.75 130.59,50.2 130.77,50.39 131.35,50.39
GND on BOTTOM (solid shape): 54.76,99.34 54.83,99.27 54.83,97.75 54.71,97.63 53.77,97.63 53.75,97.63 53.73,97.64 53.69,97.69 53.69,98.91 54.12,99.35 54.7,99.35
GND on BOTTOM (solid shape): 100.29,22.69 100.29,21.09 100.06,20.86 95.31,20.86 95.19,20.99 95.19,22.91 95.31,23.03 97.46,23.03 97.47,23.04 99.94,23.04
GND on BOTTOM (solid shape): 109.84,119.97 109.84,111.74 109.28,111.18 105.47,111.18 105.2,110.91 90.9,110.91 90.55,111.26 90.55,111.84 91.17,112.46 107.48,112.46 107.68,112.66 107.68,120.22 108.06,120.6 109.21,120.6
GND on BOTTOM (solid shape): 115.79,38.69 115.8,38.65 115.79,38.62 114.92,37.75 114.92,36.56 114.86,36.5 112.45,36.5 112.37,36.58 112.37,38.27 112.94,38.83 115.64,38.83
GND on BOTTOM (solid shape): 115.89,108.11 115.89,106.94 115.3,106.35 115.3,105.45 115.17,105.32 110.78,105.32 110.22,105.87 110.22,106.98 110.48,107.24 113.19,107.24 114.04,108.09 114.1,108.09 114.77,108.77 115.23,108.77
GND on BOTTOM (solid shape): 132.67,110.51 132.67,106.71 132.42,106.46 131.57,106.46 131.46,106.57 131.46,107.24 131.18,107.52 131.18,108.96 131.17,108.97 131.17,109.24 130.83,109.59 130.83,111.26 130.96,111.39 131.78,111.39
GND on BOTTOM (solid shape): 155.76,48.03 155.76,46.44 154.99,45.66 154.99,44.75 154.37,44.12 152.46,44.12 152.44,44.15 152.44,48.32 152.84,48.72 155.07,48.72
GND on BOTTOM (solid shape): 128.36,109.86 128.36,108.97 128.74,108.59 128.74,105.24 129.2,104.78 129.2,103.21 129.02,103.03 128.28,103.03 128.1,103.21 128.1,104.07 128,104.17 127.16,104.17 127.04,104.3 127.04,108.64 126.76,108.92 126.76,109.91 126.94,110.09 128.13,110.09
GND on BOTTOM (solid shape): 75.32,136.17 75.32,135.73 75.3,135.59 75.32,135.45 75.32,135.31 75.17,135.16 74.41,135.16 74.13,134.88 72.81,134.88 72.48,134.55 68.59,134.55 68.34,134.8 68.34,136.17 68.64,136.48 75.02,136.48
GND on BOTTOM (solid shape): 98.98,36.14 98.98,35.21 99.43,34.76 99.74,34.45 99.74,29.84 99.6,29.7 99.35,29.7 99.35,29.7 98.75,29.7 98.63,29.82 98.37,29.82 97.62,30.56 97.62,33.69 96.68,34.63 96.68,36.3 96.99,36.61 98.52,36.61
GND on BOTTOM (solid shape): 60.16,31.4 60.16,27.95 60.29,27.82 61.48,27.82 62.24,27.06 65.24,27.06 65.47,26.83 65.47,25.63 65.16,25.33 61.68,25.33 61.21,24.86 55.75,24.86 55.56,25.05 55.56,27.59 55.64,27.67 56.48,27.67 56.96,28.15 56.96,31.17 57.31,31.53 60.03,31.53
GND on BOTTOM (solid shape): 76.1,98.25 76.1,97.42 76.02,97.34 75.5,97.34 75.49,97.35 75.39,97.37 75.28,97.35 75.27,97.34 74.89,97.34 74.28,97.95 74.28,98.81 74.3,98.84 74.33,98.86 75.49,98.86
GND on BOTTOM (solid shape): 183.03,21.46 183.03,21.02 183.22,20.83 183.93,20.83 184.23,20.53 184.23,20.07 184.09,19.92 183.63,19.92 183.55,19.83 183.01,19.83 182.92,19.74 182.92,19.23 182.89,19.21 180.86,19.21 180.81,19.26 180.81,22.08 180.83,22.1 182.38,22.1
GND on BOTTOM (solid shape): 88.33,124.08 88.33,109.97 87.74,109.38 84.01,109.38 83.76,109.63 83.76,111.82 83.5,112.07 81.72,112.07 81.37,112.43 81.37,117.65 81.67,117.95 82.02,117.95 82.05,117.99 82.64,117.99 82.82,118.17 82.82,122.41 83.02,122.61 85.46,122.61 87.03,124.19 88.23,124.19
GND on BOTTOM (solid shape): 102.41,133.92 105.47,133.92 105.98,133.41 105.98,129.37 105.13,128.53 101.76,128.53 101.23,129.05 101.23,129.44 100.62,130.05 98.94,130.05 98.72,130.28 98.72,134.68 99,134.96 99.65,134.96 99.76,134.98 99.84,135.06 101.28,135.06
GND on BOTTOM (solid shape): 204.15,28.48 204.15,24.62 203.9,24.37 202.8,24.37 202.8,24.36 202.7,24.26 199.96,24.26 199.86,24.36 199.86,27.46 199.86,27.48 199.96,27.59 199.96,28.46 199.95,28.47 199.95,28.59 200.01,28.66 202.53,28.66 202.64,28.76 203.86,28.76
GND on BOTTOM (solid shape): 132.22,121.57 132.22,112.7 132.09,112.58 124.83,112.58 124.65,112.76 124.65,113.14 124.72,113.37 124.65,113.59 124.65,113.9 124.8,114.05 130.43,114.05 130.79,114.41 130.79,120.73 131.3,121.24 131.3,121.82 131.41,121.93 131.86,121.93
GND on BOTTOM (solid shape): 21.74,87.62 21.74,83.76 21.51,83.54 19.39,83.54 19.24,83.69 19.11,83.78 18.97,83.83 18.97,84.45 19.12,84.62 19.18,84.85 19.18,87.09 19.36,87.27 20.03,87.27 20.59,87.83 21.53,87.83
GND on BOTTOM (solid shape): 72.75,126.21 72.77,126.19 72.78,126.16 72.78,125.28 72.15,124.64 72.12,124.64 72.12,119.13 72.01,119.02 71.19,119.02 70.94,119.27 70.94,121.54 70.15,122.33 70.15,124.57 70.14,124.66 70.12,124.75 70.09,124.8 70.09,125.63 70.73,126.27 72.63,126.27
GND on BOTTOM (solid shape): 80.42,31.52 80.42,25.1 81.07,24.45 82.79,24.45 84.23,23 84.23,22.39 86.55,20.07 90.03,20.07 90.31,19.8 90.31,18.54 90.03,18.27 86.47,18.27 85.92,18.83 81.49,18.83 80.06,20.26 79.54,20.78 79.54,20.79 78.96,21.36 78.96,22.71 78.91,22.76 78.91,22.84 77.14,24.61 77.14,31.63 77.55,32.03 79.9,32.03
GND on BOTTOM (solid shape): 23.83,98.44 23.83,97.75 23.82,97.75 23.82,96.2 23.83,96.2 23.83,94.68 23.55,94.39 20.87,94.39 20.86,94.4 20.58,94.4 20.23,94.75 20.23,96.2 23.54,96.2 23.54,97.75 23.32,97.75 23.32,96.2 23.04,96.2 23.04,97.75 22.82,97.75 22.82,96.2 20.23,96.2 20.23,97.99 20.78,98.54 23.73,98.54
GND on BOTTOM (solid shape): 60.27,133.58 60.27,131.59 60.05,131.37 57.08,131.37 57.06,131.39 57.06,131.96 57.08,132 57.1,132.01 57.57,132.34 58.01,132.72 58.47,133.22 58.87,133.77 58.89,133.79 58.91,133.79 60.05,133.79
GND on BOTTOM (solid shape): 61.16,109.08 61.16,108.16 61.58,107.73 61.88,107.73 61.91,107.71 61.92,107.68 61.92,107.25 61.92,107.23 61.91,107.22 61.88,107.19 61.88,107.13 61.69,106.94 61.69,106.01 61.64,105.96 61.64,105.94 61.53,105.84 54.41,105.84 52.82,104.25 52.06,104.25 51.9,104.4 51.9,107.62 53.68,109.4 60.84,109.4
GND on BOTTOM (solid shape): 149.68,56.81 149.68,55.5 149.58,55.4 148.21,55.4 147.97,55.16 147.18,55.16 146.92,55.42 146.91,55.42 146.84,55.49 143.51,55.49 143.2,55.19 142.23,55.19 141.86,55.56 141.84,55.56 141.82,55.58 140.85,55.58 140.83,55.59 140.81,55.6 140.58,55.83 140.58,56.54 140.86,56.81 143.17,56.81 143.54,56.44 146.87,56.44 147.23,56.8 147.25,56.82 147.27,56.82 149.24,56.82 149.27,56.85 149.64,56.85
GND on BOTTOM (solid shape): 43.11,98.86 43.11,96.77 43.07,96.77 43.07,95.29 42.82,95.03 40.65,95.03 40.48,95.2 40.48,96.15 40.49,96.18 40.5,96.19 41.04,96.2 41.04,97.75 40.82,97.75 40.82,96.2 40.54,96.2 40.54,97.75 40.5,97.76 40.49,97.77 40.48,97.8 40.48,99.14 40.5,99.17 40.72,99.39 42.57,99.39
GND on BOTTOM (solid shape): 136.97,89.21 137,89.2 137.02,89.17 137.11,88.98 137.29,88.87 137.4,88.85 137.52,88.88 137.61,88.86 137.65,88.78 137.65,85.98 137.53,85.86 136.56,85.86 136.16,86.26 136.16,88.96 136.41,89.21
GND on BOTTOM (solid shape): 154.14,38.08 154.14,37.88 153.91,37.65 153.91,36.15 153.88,36.12 152.26,36.12 152.23,36.1 152.23,35.03 152.37,34.9 152.39,34.88 153.83,34.88 153.86,34.85 153.86,34.65 153.83,34.63 152.34,34.63 152.23,34.52 152.23,33.53 152.37,33.4 152.39,33.38 153.78,33.38 153.86,33.3 153.86,33.18 153.81,33.13 151.7,33.13 151.52,33.3 151.52,37.01 151.62,37.11 152.77,37.11 153.78,38.13 154.09,38.13
GND on BOTTOM (solid shape): 54.62,54.49 54.65,54.48 54.66,54.46 54.81,54.34 54.99,54.31 55,54.31 55.02,54.3 55.09,54.23 55.1,54.22 55.17,54.08 55.31,54 55.33,54 55.56,53.77 55.56,53.39 55.47,53.3 55.29,53.3 55.15,53.43 54.82,53.43 54.76,53.36 54.71,53.32 54.66,53.27 54.21,52.82 54.04,52.82 53.87,52.99 53.87,53.94 54.42,54.49
GND on BOTTOM (solid shape): 74.23,117.86 74.23,110.12 74,109.89 73.14,109.89 72.5,110.52 72.5,112.48 71.94,113.04 71.94,117.19 71.98,117.27 72.06,117.29 72.43,117.46 72.44,117.86 72.44,117.96 72.53,118.01 74.08,118.01
GND on BOTTOM (solid shape): 134.66,45.71 134.66,45.1 134.42,44.87 133.87,44.87 133.67,44.67 132.08,44.67 132.01,44.74 131.99,44.77 132,44.81 132,45.26 131.57,45.4 131.48,45.41 131.44,45.49 131.44,45.66 131.64,45.87 134.5,45.87
GND on BOTTOM (solid shape): 206.46,40.09 206.48,40.08 206.49,40.07 206.8,39.72 206.77,39.65 206.63,39.35 206.79,39.05 206.8,39.05 206.82,39 206.82,38.84 206.91,38.76 206.91,36.96 206.57,36.62 203.04,36.62 202.38,37.28 202.38,38.61 202.76,38.98 205.2,38.98 205.5,39.28 205.5,39.29 205.51,39.31 205.51,39.92 205.69,40.09
GND on BOTTOM (solid shape): 127.99,24.62 127.99,23.93 127.96,23.9 127.92,23.89 127.91,23.9 124.73,24.59 121.71,23.37 119.92,23.37 119.22,24.06 119.22,24.32 119.25,24.34 119.25,25.24 119.38,25.37 127.23,25.37
GND on BOTTOM (solid shape): 62.3,102.41 62.3,99.77 62.29,99.74 62.25,99.72 61.88,99.34 62.25,98.96 62.29,98.95 62.3,98.91 62.3,98.29 62.26,98.24 60.77,98.24 60.66,98.35 60.66,98.47 60.66,98.49 60.69,98.52 60.69,102.09 61.09,102.49 62.22,102.49
GND on BOTTOM (solid shape): 89.8,54.49 89.83,54.48 89.84,54.46 89.99,54.34 90.17,54.31 90.19,54.31 90.21,54.3 90.27,54.23 90.28,54.22 90.35,54.08 90.49,54 90.5,54 90.74,53.77 90.74,53.38 90.74,53.36 90.72,53.34 90.69,53.31 90.67,53.28 90.59,53.24 90.51,53.27 90.34,53.44 89.97,53.44 89.35,52.82 89.22,52.82 89.05,52.99 89.05,53.94 89.6,54.49
GND on BOTTOM (solid shape): 129.48,89.11 129.48,87.53 129.75,87.25 132.55,87.25 132.96,86.85 133.75,86.85 133.79,86.83 133.8,86.8 133.8,85.22 133.79,85.18 133.75,85.17 133.26,85.17 132.88,85.55 132.88,85.81 132.78,85.91 131.56,85.91 131.43,85.78 131.43,84.43 131.42,84.4 131.38,84.38 130.97,84.38 130.94,84.4 130.92,84.43 130.92,85.88 130.87,85.93 129.88,85.93 129.35,85.4 129.35,84.18 129.32,84.16 128.76,84.16 128.64,84.28 128.64,85.07 128.05,85.65 128.05,89.11 128.23,89.32 128.25,89.33 128.27,89.34 129.25,89.34
GND on BOTTOM (solid shape): 232.85,46.79 232.85,45.22 232.65,45.01 229.78,45.01 227.29,42.52 225.23,42.52 225.1,42.65 225.1,42.66 224.82,42.91 224.45,42.85 223.56,42.85 223.54,42.86 223.39,42.95 223.24,42.99 223.22,42.99 223.12,43.09 223.11,43.11 223.11,43.14 223.2,43.56 223.23,44 223.23,46.92 223.25,46.95 223.28,46.97 232.68,46.97
