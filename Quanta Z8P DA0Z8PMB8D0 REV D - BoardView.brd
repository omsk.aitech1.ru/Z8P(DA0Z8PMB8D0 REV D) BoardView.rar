# Allegro board Quanta Z8P DA0Z8PMB8D0 REV D - BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SP5=SD_D3=MS_D3: length 30.4
  TOP w0.127: CN2.1 v1(14.7,13) ; U13.18 27.98,31.92 27.82,31.76 v1(27.82,30.3)
  BOTTOM w0.127: v1(14.7,13) 14.35,12.65 C446.1 13.37,12.99 12.75,13.6 12.75,15.35 18.56,21.16 21.29,21.16 26.5,26.37 26.5,28.11 27.5,29.11 27.5,29.36 27.82,29.68 v1(27.82,30.3)
SP6=SD_D2=MS_CLK: length 30.9
  TOP w0.127: v1(28.7,28.77) 28.7,30.34 28.38,30.67 U13.19 ; 15.7,10.5 v1(14.7,10.5)
  BOTTOM w0.127: v1(14.7,10.5) 14.85,10.64 C447.1 15.62,11.15 16.49,12.02 16.49,16.75 19.25,19.51 21.98,19.51 28.7,26.24 v1(28.7,28.77)
SP7=SD_WP=MS_BS: length 29.6
  TOP w0.127: v1(32.6,33.98) 32.34,33.98 31.8,34.51 U13.28 ; CN2.11 v1(8.14,33.29)
  BOTTOM w0.127: v1(8.14,33.29) 9.14,32.29 19.97,32.29 21.41,30.85 23.86,30.85 25.24,32.23 30.85,32.23 v1(32.6,33.98)
SP8=SD_CD#: length 30.5
  TOP w0.127: v1(28.77,39.7) 28.77,39.5 28.38,39.11 U13.42 ; CN2.10 v1(14.65,33.07)
  BOTTOM w0.127: v1(28.77,39.7) 28.36,40.11 25.94,40.11 25.02,41.04 20.48,41.04 v1(17.35,37.91) 16.99,37.55 16.99,37.37 17.57,36.8 17.57,36.62 17.39,36.44 17.21,36.44 16.63,37.01 16.45,37.01 16.27,36.83 16.27,36.65 17.43,35.49 17.43,35.31 17.25,35.13 17.07,35.13 15.91,36.29 15.73,36.29 15.55,36.11 15.55,35.93 16.7,34.79 16.7,34.61 16.52,34.43 16.34,34.43 15.19,35.58 15.01,35.58 14.65,35.22 v1(14.65,33.07)
SPI_CLK: length 15.4
  BOTTOM w0.127: U32.3 112.82,29.54 112.59,29.31 112.16,29.31 111.58,29.88 110.53,29.88 110.23,29.59 v1(109.49,29.59) 108.59,29.59 105.73,32.45 102.22,32.45 102.09,32.58 102.09,33.79 102.47,34.17 U31.6
SPI_CLK_A: length 16.7
  TOP w0.127: v1(71.54,117.02) 69.35,119.2 U1.6
  BOTTOM w0.127: v1(71.54,117.02) 71.54,107.78 70.41,106.65 70.41,104.85 R302.2
SPI_CS0: length 13.5
  BOTTOM w0.127: U31.1 107.74,36.71 106.29,35.26 106.29,33.11 107.79,31.6 v1(107.94,31.6) 107.96,31.6 109.21,30.36 110.23,30.36 110.34,30.47 112.21,30.47 112.49,30.74 U32.6
SPI_CS0#_UR_ME: length 16.9
  TOP w0.14: U16.101 143.85,32.14 143.85,39.37 141.9,41.31 v1(141.9,42.86)
  BOTTOM w0.127: v1(146.47,41.31) 145.83,41.31 R415.2
  BOTTOM w0.14: v1(141.9,42.86) 141.9,42.55 142.72,41.74 U28.1 R415.2
SPI_DI: length 12.3
  TOP w0.127: v1(106.75,34.86) 107.59,34.86 111.34,31.11 v1(111.34,29.42)
  BOTTOM w0.127: U31.2 107.03,35.44 106.75,35.17 v1(106.75,34.86)
  BOTTOM w0.14: v1(111.34,29.42) 111.61,29.42 111.95,29.07 112.75,29.07 112.82,29.14 U32.2
SPI_DO: length 11.5
  BOTTOM w0.127: U31.5 105.9,32.9 v1(108.46,30.35) 108.75,30.05 110.36,30.05 110.46,30.16 112.33,30.16 112.51,30.34 U32.5
SPI_HOLD#: length 3.1
  BOTTOM w0.127: R417.1 133.17,39.82 v1(133.14,39.79)
  BOTTOM w0.254: R417.1 134.41,39.82 135.05,40.47 U28.7
SPI_WP#: length 3.3
  BOTTOM w0.127: v1(145.27,37.42) 145.4,37.55 R445.1
  BOTTOM w0.14: R445.1 144.62,39.2 U28.3
SPIVCC_ON: length 4.8
  TOP w0.14: v1(144.89,33.86) 144.81,33.86 R213.1 144.31,33.25 144.28,33.21 U16.100
  BOTTOM w0.14: U30.3 145.45,33.76 145.34,33.86 v1(144.89,33.86)
SPKR: length 234.7
  IN3 w0.102: 76,85.11 76.59,84.52 77.59,84.52 78.06,84.99 v1(78.24,84.99)
  IN3 w0.127: 76,85.11 74.29,85.11 73.46,84.28 71.63,84.28 69.25,81.9 66.61,81.9 65.93,81.22 62.65,81.22 46.09,64.66 46.09,62.06 45.66,61.63 45.66,47.26 47.81,45.12 47.81,40.52 54.7,33.63 80.32,33.63 81.11,34.42 89.36,34.42 90.16,33.63 96.86,33.63 97.88,34.64 103.84,34.64 104.69,33.79 107.05,33.79 108.84,35.58 114.21,35.58 114.7,36.07 115.4,36.07 116.98,37.65 116.98,38.64 119.64,41.31 125.06,41.31 126.18,40.19 128.58,40.19 128.86,39.92 129.57,39.92 131.23,38.26 132.18,38.26 133.38,37.05 138.59,37.05 139.33,37.79 142.78,37.79 143.71,36.85 146.26,36.85 146.91,36.2 148.2,36.2 149.77,34.64 152.7,34.64 153.47,35.4 164.08,35.4 165.49,33.99 168.09,33.99 169.54,32.54 170.83,32.54 179.68,23.69 186.42,23.69 186.6,23.51 192.28,23.51 193.13,24.37 193.68,24.37 v1(194.77,25.46)
  BOTTOM w0.102: U21.AK57 78.62,84.6 v1(78.24,84.99)
  BOTTOM w0.127: D25.2 196.75,26.56 196.25,26.07 195.2,26.07 194.77,25.65 v1(194.77,25.46)
SUSB#: length 182.3
  TOP w0.14: U16.119 136.68,32.97 136.45,33.2 v1(136.45,33.65)
  IN3 w0.127: v1(73.74,87.2) 73.29,86.75 71.03,86.75 70.56,87.23 65.48,87.23 63.94,85.69 62.96,85.69 62.76,85.49 52.43,85.49 51.33,84.38 50.41,84.38 49.52,83.5 49.52,82.67 49.02,82.16 49.02,77.65 50.19,76.47 50.19,73.99 49.6,73.4 49.6,72.39 49.6,72.18 43.88,66.46 43.88,44.64 45.15,43.37 45.15,39.69 53,31.85 97.62,31.85 97.76,31.99 101.3,31.99 102.17,32.87 103.09,32.87 103.95,32 107.79,32 108.47,32.68 110.62,32.68 111.24,33.31 113.23,33.31 113.58,33.66 117.27,33.66 117.77,34.16 119.61,34.16 119.94,34.5 119.94,35.29 119.14,36.09 119.14,38.27 120.37,39.51 124.34,39.51 126.83,37.03 128,37.03 129.52,35.51 130.56,35.51 130.69,35.38 130.85,35.38 130.9,35.34 131.38,35.34 132.1,34.61 135.49,34.61 v1(136.45,33.65)
  BOTTOM w0.089: U21.AC62 75.82,87.73 75.55,87.45 73.99,87.45 v1(73.74,87.2)
SUSC#: length 177.9
  TOP w0.127: U16.18 132.18,23.66 133.69,25.18 134.22,25.18 134.95,25.92 134.95,28.43 131.31,32.07 131.31,33.46 131.08,33.68 131.08,34.51 131.07,34.52 131.07,34.83 130.42,35.48 130.42,37.99 130.82,38.38 v1(130.82,39.66)
  IN3 w0.102: v1(79.67,84.93) 79.18,84.43 78.9,84.43 78.85,84.38 78.03,84.38 77.58,83.93 74.03,83.93
  IN3 w0.127: 74.03,83.93 73.68,83.58 71.64,83.58 69.46,81.39 66.82,81.39 66.14,80.71 62.86,80.71 46.81,64.66 46.81,46.83 48.31,45.33 48.31,40.73 54.91,34.14 80.11,34.14 80.9,34.93 89.57,34.93 90.37,34.14 96.65,34.14 97.67,35.15 104.05,35.15 104.9,34.3 106.84,34.3 108.63,36.09 114,36.09 114.49,36.58 115.19,36.58 116.47,37.86 116.47,38.86 119.43,41.82 125.27,41.82 126.39,40.7 128.8,40.7 129.07,40.42 130.05,40.42 v1(130.82,39.66)
  BOTTOM w0.102: v1(79.67,84.93) 79.67,84.82 U21.AK54
SUSLED#: length 97.3
  TOP w0.127: v1(132.6,19.77) 132.57,19.77 132.47,19.66 U16.28
  IN1 w0.102: v1(212.23,15.8) 211.83,15.39 181.97,15.39 180.87,16.5 178.62,16.5 175.73,19.39 165.95,19.39 164.88,20.45 155.53,20.45 154.92,19.84 151.95,19.84 150.56,18.45 150.56,17.91 150.48,17.83 148.53,15.88 136.01,15.88 134.02,17.87 134.02,18.59 132.85,19.77 v1(132.6,19.77)
  BOTTOM w0.14: CN17.9 219.85,17.45 219.63,17.23 219.63,16.35 218.52,15.24 212.79,15.24 v1(212.23,15.8)
SUSON: length 42.7
  TOP w0.127: U16.120 136.28,31.25 137.52,30.01 137.52,26.77 v1(137.66,26.63)
  TOP w0.14: R215.1 135.98,33.33 136.28,33.03 U16.120
  TOP w0.254: v1(108.72,24.36) 108.34,24.74 PR59.1
  IN2 w0.254: v1(108.72,24.36) 108.97,24.1 108.97,23.59 109.66,22.91 113.5,22.91 113.63,23.04 115.73,23.04 116.85,24.16 117.88,24.16 120.83,27.12 120.83,27.57 121.35,28.09 122.76,28.09 123.38,27.47 126.76,27.47 127.7,28.41 130.73,28.41 131.92,27.22 137.08,27.22 v1(137.66,26.63)
SVID_ALERT#_R: length 9.6
  BOTTOM w0.127: R329.2 v1(103.21,101.86) 102.86,101.51 99.3,101.51 98.91,101.12 98.91,100.43 97.05,98.58 97.05,97.81 U21.B17
SY8286BBST_S: length 1.5
  BOTTOM w0.508: PR102.1 121.43,128.05 PC88.2
SY8286BEN: length 3.4
  TOP w0.254: v1(130.37,132.8) 130.87,132.29 PC2.1 v1(131.17,133.13) PR4.1
  BOTTOM w0.229: PU5.12 130.31,132.74 v1(130.37,132.8)
SY8286BFB: length 1.5
  BOTTOM w0.229: PU5.13 PR99.2
SY8286BLDO: length 7.9
  TOP w0.127: v1(132.2,129.45) PR15.1
  TOP w0.508: v1(130.12,128.37) 130.12,129.02 130.54,129.45 PR15.1
  BOTTOM w0.229: PU5.17 128.71,130.53
  BOTTOM w0.254: 128.71,130.53 129.15,130.08
  BOTTOM w0.508: 129.15,130.08 129.81,129.42 PC85.1 PR109.1 130.39,128.1 v1(130.12,128.37)
SY8286BPG: length 4.5
  TOP w0.127: v1(130.21,135.38) PR3.1
  TOP w0.254: PR3.1 v1(129.27,134.73)
  BOTTOM w0.229: PR88.2 PR3.1 v1(129.27,134.73) 128.71,134.17 PU5.9
SY8286BSW: length 6.6
  TOP w0.381: v1(127.19,129.88) 127.19,128.24 PR17.1
  IN1 w0.762: v1(127.19,129.88) 127.04,130.03 v1(127.04,134.4)
SY8286BVOUT: length 11.4
  BOTTOM w0.203: PU5.14 130.6,131.84 PC84.2 132.57,129.87 132.57,125.34 v1(132.16,124.93) 131.57,124.34 PR125.2
SY8288CBST:
  vias: v1(139.86,80.88)
SY8288CBST_S: length 1.3
  BOTTOM w0.508: PC164.2 138.32,79.03 PR169.1
SY8288CEN: length 2.2
  TOP w0.254: PC32.1 v1(144.5,82.63)
  BOTTOM w0.229: PU11.12 144.19,82.32 v1(144.5,82.63) PC32.1
SY8288CFB: length 1.6
  BOTTOM w0.229: PU11.13 144.15,81.87 144.24,81.95 144.68,81.95 PR168.2
SY8288CPG: length 2.5
  BOTTOM w0.203: PR157.1 144.11,84.55 143.46,83.91 143.07,83.91 142.8,83.64 PU11.9
SY8288CSW: length 6.6
  TOP w0.381: v1(140.88,83.88) 141.12,83.63 PR40.1
  IN1 w0.762: v2(141.01,78.97) 140.88,79.1 v1(140.88,83.88)
SY8288CVOUT: length 14.6
  TOP w0.254: v1(144.49,81.42) 144.56,81.49 PC34.2
  BOTTOM w0.229: v1(144.49,81.42) PU11.14
  BOTTOM w0.254: PR171.2 146.09,70.11 146.09,80.48 v1(145.94,80.63) 145.68,80.89 144.93,80.89 144.49,81.33 v1(144.49,81.42)
SYS_HWPG: length 147.4
  TOP w0.14: U16.77 147.93,22.86 147.99,22.8 148.7,22.8 148.74,22.84 151.58,22.84 153,24.26 153,27.86 153.35,28.21 154.64,28.21 155.04,28.61 155.04,29.23 154.55,29.72 152.2,29.72 148.55,33.37 148.55,40.26 148.04,40.76 148.04,43.05 v1(147.62,43.48)
  IN1 w0.254: v1(147.93,87.72) 147.73,87.52 147.73,82.49 148.13,82.09 148.13,50.74 149.35,49.52 149.35,45.82 148.31,44.78 148.31,43.73 148.06,43.48 v1(147.62,43.48)
  IN3 w0.254: v1(130.09,136.79) 131.3,136.79 131.78,136.32 131.78,132.26 132.54,131.49 132.54,95.49 134.4,93.64 144.52,93.64 147.93,90.23 v1(147.93,87.72)
  BOTTOM w0.254: PR157.2 144.11,87.02 144.8,87.72 v1(147.93,87.72) ; v1(130.09,136.79) 129.74,136.79 129.27,136.32 PR87.2
SYS_SHDN#: length 168.6
  TOP w0.254: v1(132.42,134.54) 131.95,134.07 PR4.2 ; R237.2 128.93,30.35 v1(129.36,30.78)
  IN1 w0.254: v1(132.42,134.54) 131.83,133.96 131.83,132.07 132.47,131.43 132.47,127.09 v1(132.04,126.66) 131.54,126.16 131.54,125.71 132.19,125.07 132.19,95.26 v1(134.72,92.73) 135.88,92.73 136.42,93.27 142.02,93.27 144.21,91.08 146.47,91.08 148.84,88.71 148.84,83.32 v1(148.68,83.16) 148.84,83 148.84,51.04 150.07,49.81 150.07,45.53 149.06,44.52 149.06,42.88 148.8,42.63 148.8,40.62 146.2,38.02 146.2,32.98 147.12,32.06 147.12,28.77 145.9,27.55 139.67,27.55 138.94,28.28 136.98,28.28 136.63,27.93 135.36,27.93 132.02,31.26 129.81,31.26 129.48,30.93 129.48,30.89 v1(129.36,30.78)
  BOTTOM w0.254: PR109.2 131.57,127.12 v1(132.04,126.66) ; v1(148.68,83.16) 146.16,83.16 145.92,82.91 PR164.2 ; PR156.2 120.87,85.44 122.56,87.13 122.56,87.89 123.34,88.67 125.12,88.67 130.51,94.07 131.91,94.07 133.24,92.73 v1(134.72,92.73)
SYS_SHDN#_R: length 1.7
  TOP w0.14: R237.1 U16.2
TEMP_MBAT#: length 96.7
  TOP w0.14: U16.73 146.38,21.26 145.69,20.57 144.08,20.57 143.81,20.84 143.81,21.44 145.19,22.81 v1(145.19,26.97) ; PR79.1 PR73.2 73.77,18.8 v1(72.96,19.61) 72.71,19.86 v1(72.71,20.84)
  IN1 w0.102: v1(72.71,20.84) 74.06,22.19 83.7,22.19 85.27,20.63 90.64,20.63 91.18,20.09 102.32,20.09 103.79,21.56 111.66,21.56 112.56,22.46 116.17,26.07 116.64,26.07 117.47,26.9 117.66,26.9 121.07,30.32 122.48,30.32 125.25,33.09 126.75,33.09 128.17,31.67 128.17,30.76 128.6,30.33 132.56,30.33 135.24,27.65 136.74,27.65 137.09,28 138.82,28 139.55,27.27 143.65,27.27 143.95,26.97 v1(145.19,26.97)
TERM9:
  vias: v1(39.05,105.24) v2(39,108.8) v2(39,108.04) v2(39,107.28) v2(39,106.52)
THERMTRIP#: length 268.2
  TOP w0.127: U16.122 135.48,31.36 137.2,29.65 137.2,26.44 139.64,23.99 v1(139.64,23.93)
  TOP w0.14: R24.2 81.67,100.25 v1(81.77,100.34)
  IN1 w0.102: v1(139.64,23.93) 138.95,23.24 136.03,23.24 135.6,23.67 132.12,23.67 129.52,26.28 123.09,26.28 122.41,25.6 121.87,25.6 118.24,21.98 118.24,19.87 115.14,16.77 84.27,16.77 83.48,15.99 68.24,15.99 59.13,25.1 56,25.1 53.24,27.86 37.54,27.86 34.88,25.19 v1(29.53,25.19)
  IN3 w0.127: v1(29.53,25.19) 28.39,25.19 24.88,28.71 24.88,32.41 25.8,33.33 25.8,38.62 24.66,39.75 24.66,41.48 24.45,41.69 24.45,56.88 24.37,56.97 24.37,69.41 25.4,70.44 26.14,70.44 26.49,70.78 26.49,75.27 26.9,75.68 26.9,85.42 29.71,88.22 29.71,89.34 31.92,91.55 34.13,91.55 38.68,96.1 42.76,96.1 44.98,98.31 50,98.31 58.4,106.71 63.23,106.71 63.91,107.39 73.66,107.39 75.17,105.88 75.17,104.32 76.33,103.15 76.33,101.94 77.33,100.95 79.47,100.95 80.07,100.34 v1(81.77,100.34)
THERMTRIP#_SOC: length 9.1
  TOP w0.14: R23.1 80.03,99.47 R24.1 v1(82.16,99.47) 82.28,99.47 83.06,98.68 83.06,97.41 83.26,97.21 83.26,96.3 83.19,96.22 83.19,94.25 v1(83.64,93.79)
  BOTTOM w0.102: v1(83.64,93.79) 83.36,94.08 U21.J47
TP_PWR: length 1.6
  BOTTOM w0.305: CN3.31 61.59,125.45 ; CN3.30 61.39,124.95
  vias: v1(61.89,124.37)
TPCLK: length 55.9
  TOP w0.127: v1(147.74,32.64) 147.74,32.55 150.01,30.28 v1(150.01,29.32) 150.01,28.18 149.5,27.66 U16.89 ; v1(128.63,34.11) 127.73,34.11 126.79,33.17 126.67,33.17 125.05,31.55 125.05,30.8 124.29,30.04 124.29,27.56 123.01,26.28 122.17,26.28 118.6,22.71 116.68,22.71 v1(116.57,22.6) 116.18,22.6 116.06,22.72 115.44,22.72 114.88,22.15 114.89,22.15
  TOP w0.14: 114.89,22.15 114.83,22.09 R259.1
  IN3 w0.127: v1(128.63,34.11) 128.77,34.11 128.89,33.99 129.65,33.99 130.56,33.07 134.01,33.07 135.02,32.06 140.95,32.06 141.47,32.58 146.55,32.58 146.98,32.15 147.24,32.15 v1(147.74,32.64)
  BOTTOM w0.127: CN15.2 114.7,22.05 114.49,22.26 114.49,22.62 D28.2 114.49,23.11 114.49,23.32 114.74,23.58 116.06,23.58 116.57,23.07 v1(116.57,22.6)
TPD_EN: length 62.5
  TOP w0.14: v1(145.9,30.77) 145.95,30.82 145.95,33.19 v1(146.47,33.71) 146.47,34.42 145.75,35.14 R214.2 ; v1(108.9,19.46) 108.9,18.78 109.41,18.27 109.41,17.78 ESD4.4 109.36,17.24 109.09,17.24 108.44,17.89 108.44,19.82 108.62,19.99 108.62,20.88 109.08,21.34 109.97,21.34 111.24,22.61 113.96,22.61 115.11,23.76 118.18,23.76 120.97,26.56 120.97,27.11 121.52,27.65 122.37,27.65 123.25,28.53 123.25,30.49 124.02,31.27 124.02,32 126.47,34.44 126.47,34.89 126.74,35.16 v1(127.68,35.16)
  IN2 w0.127: v1(127.68,35.16) 127.97,34.87 127.97,34.14 128.5,33.61 128.92,33.61 129.3,33.99 129.9,33.99 130.31,33.58 130.97,33.58 131.24,33.86 133.17,33.86 135.58,31.45 141.27,31.45 142.79,29.94 145.07,29.94 v1(145.9,30.77)
  BOTTOM w0.127: CN15.8 108.7,19.66 v1(108.9,19.46)
TPD_INT#: length 43.6
  TOP w0.127: v1(109.44,19.11) 109.44,19.55 108.98,20.02 108.98,20.66 109.18,20.86 109.33,20.86 ESD4.3 109.43,20.31 109.43,20.08 v1(109.99,19.52)
  TOP w0.14: v1(128.29,35.39) 128.06,35.63 126.81,35.63 126.19,35.01 126.19,34.56 123.74,32.11 123.74,31.39 122.97,30.61 122.97,28.65 122.24,27.92 121.39,27.92 120.69,27.23 120.69,26.67 118.06,24.04 114.99,24.04 113.85,22.89 111.14,22.89 109.87,21.62 108.74,21.62 108.59,21.48 107.97,21.48 107.82,21.32 R261.1 107.39,20.48 v1(107.39,20.27) 107.4,20.26 Q20.5 ; v1(131.17,36.03) 131.2,36.03 R208.2
  IN1 w0.114: v1(128.29,35.39) 130.53,35.39 v1(131.17,36.03)
  BOTTOM w0.127: v1(107.39,20.27) 107.39,19.78 108.19,18.97 109.31,18.97 v1(109.44,19.11) ; CN15.7 109.7,19.81 v1(109.99,19.52)
TPDATA: length 56.7
  TOP w0.127: v1(128.59,34.77) 128.45,34.63 127.52,34.63 126.7,33.81 126.57,33.81 124.54,31.78 124.54,31.02 123.77,30.25 123.77,27.77 122.8,26.8 121.96,26.8 118.39,23.24 v1(117.21,23.24) 115.33,23.24 114.24,22.15 ; v1(147.1,32.76) 147.1,32.45 v1(148.2,31.36) 149.49,30.07 149.49,28.62 148.77,27.9 148.08,27.9 147.92,28.06 U16.90
  TOP w0.14: 114.24,22.15 114.24,21.89 R258.1
  IN3 w0.127: v1(147.1,32.76) 146.78,33.09 141.24,33.09 140.74,32.58 135.24,32.58 134.24,33.58 130.77,33.58 129.86,34.49 129.1,34.49 128.82,34.77 v1(128.59,34.77)
  BOTTOM w0.127: CN15.3 113.7,21.93 113.91,22.13 113.91,22.51 D27.2 113.91,23.22 113.91,23.47 114.51,24.08 116.36,24.08 v1(117.21,23.24)
TPM_BADD: length 2
  TOP w0.14: R221.2 v1(154.21,33.74) 154.39,33.74 154.51,33.62 U14.6
TPM_PP: length 2.3
  TOP w0.14: U14.4 154.67,34.62 154.33,34.96 TP16.1
TS_EN: length 289
  TOP w0.14: v1(151.62,25.94) 151.62,25.78 152.22,25.18 R250.1
  IN1 w0.102: v1(151.62,25.94) 151.11,26.45 149.63,26.45 146.13,22.95 141.37,22.95 140.58,22.16 135.9,22.16 135.22,22.84 131.52,22.84 129.09,25.26 123.56,25.26 122.87,24.57 122.3,24.57 119.28,21.55 119.28,16.57 118.45,15.74 84.7,15.74 81.72,12.77 38.6,12.77 37.41,13.97 37.41,15.86 36.89,16.38 36.89,16.82 30.84,22.87 28.95,22.87 18.67,33.14 18.67,52.15 18.93,52.41 18.93,68.95 17.18,70.69 17.18,75.79 18.62,77.24 18.62,82.03 18.15,82.5 18.15,82.89 15.81,85.22 15.3,85.22 14.29,86.24 14.29,86.49 12.37,88.4 12.37,90.48 22.03,100.14 40.57,100.14 43.31,102.88 43.31,106.09 47.84,110.61 58.7,110.61 60.74,112.65 60.74,123.07 v1(59.86,123.95)
  BOTTOM w0.14: CN3.28 v1(59.86,123.95)
TS_EN_C: length 4.6
  TOP w0.14: U16.81 148.58,24.46 v1(148.63,24.41) 149.6,24.41 C256.1 150.17,24.98 151.38,24.98 R250.2
TYPEC_CHG: length 2.5
  TOP w0.254: U3.7 28.55,91.85 v1(29.06,92.36) 29.83,93.13 R51.2
TYPEC_CHG_HI: length 3.1
  TOP w0.254: R50.2 R49.1 27.67,92.47 v1(27.79,92.36) 28.05,92.1 U3.8
TYPEC_HPD#: length 73.8
  TOP w0.14: v1(28.37,83.14) 28.06,83.46 28.06,83.77 28.03,83.8 28.03,83.8 27.6,84.23 R78.1
  IN3 w0.127: v1(71.61,106.09) 71.13,106.56 64.17,106.56 63.54,105.93 58.69,105.93 50.31,97.55 45.29,97.55 42.96,95.22 38.88,95.22 36.23,92.56 36.23,90.52 31.2,85.49 31.2,84.7 29.64,83.14 v1(28.37,83.14)
  BOTTOM w0.102: U21.A50 81.69,98.11 81.44,98.37 81.44,98.58 79.43,100.59 78.24,100.59 77.94,100.28 77.31,100.28 76.14,101.45 75.05,101.45 74.91,101.6 74.91,102.19 75.35,102.64 75.35,102.98
  BOTTOM w0.127: v1(71.61,106.09) 72.01,106.5 72.13,106.5
  BOTTOM w0.14: 75.35,102.98 75.35,104.5 74.81,105.04 74.81,105.67 73.87,106.61 72.24,106.61 72.13,106.5
USB3_0_RXN: length 147.6
  TOP w0.127: R167.2 28.26,44.95 L3.3 28.85,44.95 29.15,45.24 29.29,45.24 C170.2 30.22,44.7 30.3,44.78 31.3,44.78 31.74,45.22 32.24,45.22 32.29,45.16 32.29,44.95 v1(32.13,44.79)
  IN1 w0.089: 103.94,92.82 103.92,92.82 103.91,92.83 100.88,92.83 100.45,93.25 100.45,94.14 100.23,94.36 v1(100.11,94.36)
  IN1 w0.102: v1(32.13,44.79) 32.33,44.98 32.33,45.13 31.78,45.67 29.64,45.67 26.22,49.09 26.22,50.23 24.79,51.66 24.79,54.06 32.83,62.1 32.83,70.18 35.19,72.55 40.61,72.55 41.83,71.33 53.03,71.33 62.44,80.74 62.44,85.12 61.97,85.59 61.97,90.85 65,93.88 67.83,93.88 68.16,93.55 71.77,93.55 74.34,90.98 74.61,90.98 74.62,90.97 86.94,90.97 87.15,91.18 91.88,91.18 92.51,90.55 92.51,87.71 92.76,87.46 95.14,87.46 95.36,87.24 103.75,87.24 105.84,89.33 107.12,89.33 107.56,89.77 107.56,90.11 105.85,91.83 105.09,91.83 104.1,92.82 103.94,92.82
  BOTTOM w0.102: v1(100.11,94.36) 100.26,94.36 100.44,94.17 100.44,93.93 U21.K10
USB3_0_RXN_R: length 18.2
  TOP w0.127: R167.1 27.26,44.95 L3.4 26.39,44.95 26.24,45.1 25.38,45.1 v1(25.01,44.73) 24.63,45.12 22.14,45.12 19.6,47.66 19.05,47.66 ESD3.6 18.91,47.66 18.55,47.66 18.35,47.45 17.84,47.45 17.66,47.63 16.98,47.63 16.9,47.55 16.9,46.82 16.71,46.63 16.71,45.42 15.86,44.58 14.85,44.58 14.09,43.82 CN8.5
USB3_0_RXP: length 147.6
  TOP w0.127: R165.2 28.26,45.75 L3.2 28.89,45.75 29.15,45.5 29.39,45.5 29.73,45.16 29.73,45.16 29.74,45.16 29.86,45.16 C169.2 30.21,45.3 30.48,45.03 31.19,45.03 31.63,45.47 32.35,45.47 32.55,45.27 32.55,44.91 32.68,44.79 v1(32.79,44.79)
  IN1 w0.089: 103.94,93.01 103.92,93.01 103.91,93 100.95,93 100.63,93.32 100.63,94.11 v1(100.82,94.3)
  IN1 w0.102: v1(32.79,44.79) 32.65,44.79 32.53,44.91 32.53,45.22 31.87,45.88 29.72,45.88 26.43,49.17 26.43,50.31 24.99,51.75 24.99,53.97 33.03,62.01 33.03,70.1 35.28,72.34 40.52,72.34 41.74,71.13 53.11,71.13 62.64,80.66 62.64,85.2 62.17,85.67 62.17,90.77 65.09,93.68 67.75,93.68 68.08,93.35 71.68,93.35 74.25,90.78 87.01,90.78 87.23,90.99 91.8,90.99 92.32,90.48 92.32,87.63 92.68,87.27 95.06,87.27 95.28,87.05 103.83,87.05 105.92,89.14 107.2,89.14 107.76,89.69 107.76,90.19 105.93,92.02 105.17,92.02 104.18,93.01 103.94,93.01
  BOTTOM w0.102: v1(100.82,94.3) 101.07,94.06 U21.K9
USB3_0_RXP_R: length 18.1
  TOP w0.127: CN8.6 14.56,44.83 15.76,44.83 16.46,45.53 16.46,46.73 16.65,46.92 16.65,47.66 16.87,47.88 17.08,47.88 ESD3.5 17.28,47.88 17.77,47.88 17.94,47.71 18.24,47.71 18.45,47.91 19.71,47.91 22.24,45.37 24.38,45.37 v1(25.01,46) 25.01,45.67 25.33,45.35 26.05,45.35 26.45,45.75 L3.1 27.26,45.75 R165.1
USB3_0_TXN: length 127.3
  TOP w0.127: C159.1 25.96,52.33 v1(26.17,52.33)
  IN1 w0.102: v1(106.2,94.86) 106.4,94.65 106.4,92.27 108.17,90.5 108.17,89.41 107.39,88.63 105.93,88.63 103.99,86.68 94.35,86.68 94.01,87.03 92.46,87.03 91.97,87.52 91.97,90.31 91.62,90.66 87.6,90.66 87.2,90.27 74.83,90.27 74.82,90.28 73.97,90.28 72.53,91.72 70.83,91.72 69.82,92.74 64.85,92.74 63.98,91.88 63.98,86.33 63.98,86.24 63.66,85.92 63.15,85.41 63.15,80.48 53.31,70.64 41.54,70.64 40.66,71.52 35.36,71.52 33.54,69.7 33.54,61.84 29.6,57.9 29.6,57.38 26.82,54.59 26.29,54.59 25.49,53.79 25.49,52.87 25.84,52.52 25.98,52.52 v1(26.17,52.33)
  BOTTOM w0.102: U21.J2 104.68,94.66 105.99,94.66 v1(106.2,94.86)
USB3_0_TXN_C: length 2
  TOP w0.127: C159.2 24.81,52.16 24.67,52.3 24.39,52.3 24.12,52.03 L1.3 23.34,52.03 R157.2
USB3_0_TXN_R: length 11.4
  TOP w0.127: R157.1 22.03,51.92 L1.4 21.53,52.03 21.44,52.12 21.07,52.12 20.94,51.99 C161.1 20.39,52.08 19.95,52.08 19.66,51.78 19.66,51.11 19.4,50.86 19.05,50.86 ESD3.10 18.91,50.86 16.74,50.86 16.6,50.72 16.6,50.4 15.98,49.78 14.89,49.78 14.72,49.95 14.29,49.95 14.09,49.74 CN8.8
USB3_0_TXP: length 127.3
  TOP w0.127: v1(26.22,53.1) 26.22,52.89 26.09,52.77 25.73,52.77 C154.1
  IN1 w0.102: v1(26.22,53.1) 26.22,52.88 26.06,52.72 25.93,52.72 25.69,52.96 25.69,53.7 26.38,54.39 26.9,54.39 29.81,57.29 29.81,57.82 33.74,61.75 33.74,69.62 35.45,71.32 40.58,71.32 41.46,70.44 53.4,70.44 63.36,80.4 63.36,85.33 63.46,85.43 64.19,86.16 64.19,86.41 64.19,91.79 64.93,92.54 69.73,92.54 70.75,91.52 72.44,91.52 73.89,90.08 87.28,90.08 87.67,90.47 91.54,90.47 91.78,90.23 91.78,87.44 92.38,86.84 93.93,86.84 94.27,86.49 104.06,86.49 106.01,88.44 107.47,88.44 108.36,89.33 108.36,90.58 106.59,92.35 106.59,94.75 106.68,94.83 v1(106.85,94.83)
  BOTTOM w0.102: U21.J1 105.14,94.45 106.47,94.45 v1(106.85,94.83)
USB3_0_TXP_C: length 2
  TOP w0.127: C154.2 24.81,52.74 24.62,52.55 24.41,52.55 24.13,52.83 L1.2 23.34,52.83 R153.2
USB3_0_TXP_R: length 11.4
  TOP w0.127: CN8.9 14.09,50.94 15,50.04 15.88,50.04 16.34,50.5 16.34,50.82 16.63,51.11 17.11,51.11 ESD3.1 17.25,51.11 19.29,51.11 19.4,51.22 19.4,51.89 19.85,52.33 20.48,52.33 C155.1 20.94,52.58 21.15,52.37 21.31,52.37 21.77,52.83 L1.1 22.03,52.94 R153.1
USB3_1_RXN: length 118.3
  TOP w0.127: v1(15.93,89.47) 15.35,89.47 15.02,89.14 13.36,89.14 12.96,88.74 12.96,88.09 12.5,87.62 11.72,87.62 11.49,87.85 11.49,88.38 11.4,88.47 11.15,88.47 ESD2.2 10.98,88.47 10.6,88.47 10.22,88.09 9.73,88.09 v1(9.55,87.91)
  IN1 w0.102: v1(105.98,96.73) 105.74,96.97 105.19,96.97 104.6,96.38 98.46,96.38 96.51,98.33 96.51,98.85 96.2,99.16 95.3,99.16 94.54,99.92 93.34,99.92 91.26,102 90.16,102 85.78,106.38 82.07,106.38 80.33,104.64 69.81,104.64 69.64,104.82 53.58,104.82 48.77,100.01 46.76,100.01 42.91,96.16 23.57,96.16 17.48,90.06 16.36,90.06 15.93,89.64 v1(15.93,89.47) ; v1(9.55,87.91) 9.32,88.14 7.6,88.14 7.16,87.7 5.55,87.7 CN1.B10
  BOTTOM w0.089: U21.G2 104.53,95.34 105.21,95.34 105.55,95.67 105.56,95.67 105.57,95.69 105.57,96
  BOTTOM w0.102: 105.57,96 105.57,96.86 105.68,96.96 105.75,96.96 v1(105.98,96.73)
USB3_1_RXP: length 118.3
  TOP w0.127: v1(15.46,89.93) 14.92,89.39 13.25,89.39 12.71,88.84 12.71,88.19 12.39,87.88 12.12,87.88 ESD2.8 11.91,87.88 11.82,87.88 11.75,87.95 11.75,88.49 11.51,88.72 10.5,88.72 10.12,88.35 9.77,88.35 v1(9.55,88.57)
  IN1 w0.102: CN1.B11 5.55,87.9 7.08,87.9 7.51,88.34 9.32,88.34 v1(9.55,88.57) ; v1(15.46,89.93) 15.94,89.93 16.27,90.27 17.39,90.27 23.49,96.36 42.82,96.36 46.68,100.21 48.69,100.21 53.49,105.02 69.72,105.02 69.9,104.84 80.25,104.84 81.99,106.58 85.87,106.58 90.24,102.21 91.34,102.21 93.42,100.12 94.62,100.12 95.38,99.36 96.29,99.36 96.71,98.94 96.71,98.42 98.55,96.58 104.52,96.58 105.11,97.17 105.71,97.17 v1(105.95,97.41)
  BOTTOM w0.089: U21.F2 104.77,95.52 105.14,95.52 105.37,95.75 105.37,96.09
  BOTTOM w0.102: v1(105.95,97.41) 105.71,97.17 105.6,97.17 105.37,96.94 105.37,96.09
USB3_1_TXN: length 113.1
  TOP w0.127: C36.1 13.93,90.9 13.93,91.07 13.99,91.14 15.21,91.14 15.4,90.95 v1(15.4,90.69)
  IN1 w0.102: v1(15.4,90.69) 15.4,91.02 15.54,91.16 16.3,91.16 16.98,91.85 18.16,91.85 23.15,96.84 42.62,96.84 46.49,100.71 48.33,100.71 51.81,104.18 51.81,104.77 52.54,105.5 69.92,105.5 70.1,105.33 77.79,105.33 79.53,107.06 86.07,107.06 90.17,102.97 92.46,102.97 95.58,99.85 96.82,99.85 97.44,99.23 97.44,98.39 98.75,97.08 104.1,97.08 104.98,97.95 106.55,97.95 107.01,97.49 107.01,96.87 v1(106.75,96.62)
  BOTTOM w0.102: v1(106.75,96.62) 106.87,96.62 107.05,96.44 107.05,95.92 107.32,95.65 107.32,94.62 106.65,93.95 104.81,93.95 U21.K2
USB3_1_TXN_CN: length 9.2
  TOP w0.127: C36.2 13.46,90.78 13.33,90.91 12.82,90.91 12.67,90.77 12.67,89.29 12.34,88.95 12.09,88.95 ESD2.9 11.95,88.95 10.28,88.95 10.15,89.08 9.46,89.08 9.1,88.72 9.1,88.29 8.58,87.77 7.89,87.77 7.67,87.55 CN1.A3
USB3_1_TXP: length 113.1
  TOP w0.127: C28.1 14.44,91.39 15.21,91.39 v1(15.39,91.57)
  IN1 w0.102: v1(107.41,96.62) 107.21,96.82 107.21,97.58 106.63,98.15 104.89,98.15 104.02,97.28 98.84,97.28 97.65,98.47 97.65,99.31 96.9,100.05 95.66,100.05 92.55,103.17 90.25,103.17 86.15,107.27 79.45,107.27 77.71,105.53 70.18,105.53 70,105.71 52.45,105.71 51.6,104.86 51.6,104.27 48.25,100.91 46.41,100.91 42.54,97.04 23.07,97.04 18.08,92.05 16.9,92.05 16.22,91.37 15.59,91.37 v1(15.39,91.57)
  BOTTOM w0.102: U21.K3 104.2,93.75 104.49,93.46 104.74,93.46 105.02,93.74 106.73,93.74 107.52,94.53 107.52,95.73 107.25,96 107.25,96.46 v1(107.41,96.62)
USB3_1_TXP_CN: length 9.2
  TOP w0.127: C28.2 13.46,91.33 13.29,91.17 12.71,91.17 12.42,90.87 12.42,89.4 12.23,89.21 11.15,89.21 ESD2.1 10.99,89.21 10.38,89.21 10.26,89.33 9.35,89.33 8.85,88.83 8.85,88.4 8.48,88.02 7.83,88.02 7.81,88.05 CN1.A2
USB3_2_RXN: length 113.5
  TOP w0.127: CN1.A10 7.86,84.05 7.89,84.02 8.57,84.02 8.97,84.42 9.11,84.42 9.68,84.98 9.88,84.98 10.68,85.78 10.97,85.78 ESD2.5 11.17,85.78 11.39,85.78 11.49,85.89 11.49,86.42 11.72,86.64 15.05,86.64 v1(15.26,86.85)
  IN1 w0.102: v1(101.48,93.42) 101.72,93.66 102,93.66 102.29,93.94 102.29,94.55 101.58,95.26 98.87,95.26 95.47,98.66 95.12,98.66 94.34,99.44 93.13,99.44 91.2,101.37 90.11,101.37 85.58,105.9 82.68,105.9 80.94,104.16 69.61,104.16 69.44,104.33 53.79,104.33 48.98,99.52 46.95,99.52 43.11,95.67 23.78,95.67 18.22,90.11 18.22,87.33 17.54,86.66 15.45,86.66 v1(15.26,86.85)
  BOTTOM w0.102: U21.M7 101.78,93.13 v1(101.48,93.42)
USB3_2_RXP: length 113.4
  TOP w0.127: v1(15.26,86.2) 15.07,86.39 12.12,86.39 ESD2.6 11.91,86.39 11.82,86.39 11.75,86.32 11.75,85.78 11.49,85.53 10.79,85.53 9.98,84.73 9.78,84.73 9.22,84.16 9.07,84.16 8.68,83.77 7.89,83.77 7.67,83.55 CN1.A11
  IN1 w0.102: v1(15.26,86.2) 15.26,86.39 15.32,86.45 15.45,86.45 15.45,86.45 17.63,86.45 18.42,87.25 18.42,90.03 23.86,95.47 43.19,95.47 47.04,99.31 49.06,99.31 53.88,104.13 69.35,104.13 69.53,103.95 81.03,103.95 82.77,105.69 85.5,105.69 90.02,101.17 91.11,101.17 93.05,99.24 94.25,99.24 95.03,98.45 95.38,98.45 98.78,95.05 101.49,95.05 102.08,94.46 102.08,94.02 101.92,93.86 101.54,93.86 101.46,93.94 v1(101.46,94.32)
  BOTTOM w0.102: U21.K7 101.6,93.85 101.46,93.99 v1(101.46,94.32)
USB3_2_TXN: length 122.6
  TOP w0.127: C51.1 14.13,88.01 14.13,87.88 14.26,87.76 14.74,87.76 15.16,88.18 v1(15.16,88.32)
  IN1 w0.102: v1(15.16,88.32) 15.16,88.16 14.88,87.88 14.42,87.88 14,88.31 14,90.95 20.57,97.53 42.34,97.53 46.22,101.41 47.78,101.41 50.72,104.34 50.72,105.49 51.77,106.55 73.46,106.55 75.14,108.23 85.87,108.23 90.45,103.65 92.75,103.65 95.85,100.55 97.84,100.55 99.17,99.22 99.17,98.58 99.85,97.9 103.47,97.9 104.21,98.64 106.87,98.64 109.46,96.04 109.46,95.87 109.38,95.78 v1(108.96,95.78)
  BOTTOM w0.102: U21.L1 105.39,93.29 105.58,93.48 106.89,93.48 108.61,95.19 109.23,95.19 109.44,95.4 109.44,95.81 109.33,95.92 109.1,95.92 v1(108.96,95.78)
USB3_2_TXN_CN: length 11.9
  TOP w0.127: C51.2 13.67,88.08 13.54,87.94 13.19,87.94 12.38,87.13 12.08,87.13 ESD2.7 11.96,87.13 11.71,87.13 11.65,87.18 10.3,87.18 10.02,86.91 10.02,86.58 v1(9.79,86.34)
  IN1 w0.102: CN1.B3 5.45,84 8.74,84 9.64,84.9 9.96,84.9 10.07,85.01 10.07,86.05 v1(9.79,86.34)
USB3_2_TXP: length 122.6
  TOP w0.127: C55.1 14.65,87.51 v1(15.16,87.51)
  IN1 w0.102: v1(15.16,87.51) 14.99,87.68 14.34,87.68 13.8,88.22 13.8,91.04 20.49,97.73 42.25,97.73 46.14,101.61 47.7,101.61 50.51,104.43 50.51,105.57 51.69,106.75 73.37,106.75 75.06,108.43 85.96,108.43 90.53,103.86 92.83,103.86 95.93,100.75 97.93,100.75 99.37,99.3 99.37,98.66 99.93,98.1 103.39,98.1 104.12,98.84 106.95,98.84 109.66,96.13 109.66,95.97 v1(109.86,95.78)
  BOTTOM w0.102: v1(109.86,95.78) 109.64,95.56 109.64,95.31 109.32,94.99 108.69,94.99 106.97,93.27 105.66,93.27 105.47,93.09 105.33,93.09 105.25,93.01 104.84,93.01 104.74,93.12 104.41,93.12 U21.L2
USB3_2_TXP_CN: length 11.9
  TOP w0.127: C55.2 13.67,87.53 13.51,87.69 13.3,87.69 12.48,86.87 11.6,86.87 11.54,86.93 11.21,86.93 ESD2.4 10.92,86.93 10.41,86.93 10.28,86.8 10.28,86.51 v1(10.45,86.34)
  IN1 w0.102: CN1.B2 5.65,83.8 8.82,83.8 9.72,84.7 10.05,84.7 10.28,84.93 10.28,86.17 v1(10.45,86.34)
USB_OC0#: length 68
  TOP w0.127: R68.1 30.81,85.67 30.17,86.31 v1(30.17,86.64)
  IN3 w0.127: v1(30.17,86.64) 31.13,87.6 32.95,87.6 35.97,90.63 35.97,92.67 38.78,95.48 42.86,95.48 45.19,97.8 50.21,97.8 58.59,106.18 63.43,106.18 64.06,106.82 71.63,106.82 v1(72.35,106.1)
  BOTTOM w0.102: U21.B55 79.4,97.85 79.4,98.94 79.04,99.3 78.52,99.3 77.94,99.88 77.14,99.88 76.05,100.98 74.2,100.98 73.27,101.91 R327.1 72.35,102.31 71.76,102.9
  BOTTOM w0.127: v1(72.35,106.1) 72.35,105.58 71.31,104.54 71.31,103.35 71.76,102.9
USB_OC1#: length 361.5
  TOP w0.127: U18.3 222.6,13.14 v1(222.36,13.37)
  TOP w0.14: v1(25.23,59.13) 26.06,59.13 28.08,57.11 28.08,55.61 27.12,54.64 U7.3
  IN1 w0.102: v1(35.62,30.28) 36.64,30.28 38.65,28.26 56.54,28.26 68.41,16.39 83.32,16.39 84.1,17.18 114.98,17.18 117.83,20.04 117.83,22.14 121.7,26.01 122.23,26.01 122.9,26.68 129.68,26.68 131.38,24.99 141.68,24.99 141.89,24.78 144.39,24.78 147.91,28.3 148.97,28.3 149.9,29.23 151.71,29.23 152.43,29.95 155.46,29.95 156.57,31.06 157.16,31.06 158.27,29.95 159.29,29.95 161.74,32.4 162.1,32.4 163.1,31.4 163.1,27.03 166.48,23.65 175.2,23.65 177.74,21.11 177.74,17.79 178.79,16.73 180.92,16.73 182.06,15.6 211.04,15.6 v1(211.25,15.8)
  IN3 w0.127: v1(35.62,30.28) 35.24,30.66 35.24,34.42 33.98,35.69 33.98,38.23 31.7,40.51 31.7,43.61 29.93,45.38 27.81,45.38 25.21,47.97 25.21,54.98 27.13,56.9 27.13,58.13 26.13,59.13 v1(25.23,59.13) 25.23,59.57 25.19,59.62 25.19,69.28 25.59,69.68 26.46,69.68 27.04,70.25 27.04,75.01 27.41,75.38 27.41,84.91 28.25,85.75 29.35,85.75 29.71,86.11 29.71,86.97 30.53,87.79 30.53,89.8 31.97,91.24 34.19,91.24 38.79,95.84 42.87,95.84 45.08,98.06 50.1,98.06 58.51,106.46 63.34,106.46 63.95,107.07 72.37,107.07 v1(73.3,106.14)
  BOTTOM w0.102: 75.09,102.98 75.09,102.82 74.74,102.47 74.44,102.47 R328.1 74.28,101.48 74.56,101.21 76.1,101.21 77.23,100.08 78.03,100.08 78.61,99.5 79.13,99.5 79.62,99.01 79.62,98.05 79.83,97.84 79.83,97.58 79.54,97.29 U21.C55
  BOTTOM w0.14: v1(73.3,106.14) 73.3,105.52 75.09,103.74 75.09,102.98 ; v1(222.36,13.37) 221.64,12.66 212.08,12.66 211.25,13.49 v1(211.25,15.8)
USB_OTG_ID: length 12.5
  IN2 w0.089: 105.56,88.17 99.07,88.17 v1(98.67,87.76)
  IN2 w0.14: v1(106.03,87.81) 105.67,88.17 105.56,88.17
  BOTTOM w0.102: v1(98.67,87.76) 98.23,87.32 U21.AC15 ; R377.1 R382.1 108.33,87.75 v1(108.09,87.51) 107.98,87.4 106.44,87.4 v1(106.03,87.81)
USB_SSIC_RCOMP: length 2.6
  TOP w0.203: R64.1 98.21,87.18 98.21,88.19 v1(98.58,88.56)
  BOTTOM w0.203: U21.AB15 98.58,88.55 v1(98.58,88.56)
USBCOMP: length 3.8
  TOP w0.203: R75.1 97.8,85.94 97.91,86.05 97.91,88.59 v1(97.9,88.59)
  BOTTOM w0.203: v1(97.9,88.59) 97.9,88.83 U21.Y15
USBON#: length 250.1
  TOP w0.14: U18.4 224.81,13.14 v1(224.8,13.13) ; v1(27.6,55.96) 27.6,56.43 26.99,57.04 U7.4 ; U16.99 144.68,31.36 143.86,30.54 143.86,30.41 142.08,28.63 142.08,25.55 v1(142.24,25.39)
  IN1 w0.102: v1(43.01,31.93) 43.01,30.51 44.86,28.67 56.71,28.67 68.58,16.8 83.15,16.8 83.93,17.59 114.81,17.59 117.43,20.21 117.43,22.31 121.53,26.42 121.99,26.42 122.66,27.09 129.85,27.09 131.55,25.4 137.34,25.4 137.68,25.74 141.89,25.74 v1(142.24,25.39)
  IN3 w0.127: v1(142.24,25.39) 142.35,25.5 146.39,25.5 146.77,25.13 153.35,25.13 153.78,25.56 153.78,26.87 154.08,27.16 160.01,27.16 160.31,27.46 171.25,27.46 177.47,21.25 180.62,21.25 188.43,13.44 210.96,13.44 211.34,13.82 213.03,13.82 213.92,12.93 224.6,12.93 v1(224.8,13.13) ; v1(27.6,55.96) 27.6,55.22 26.84,54.47 26.5,54.47 25.72,53.69 25.72,51.14 26.44,50.42 26.44,49.15 29.64,45.96 34.85,45.96 35.45,45.36 35.45,39.49 v1(43.01,31.93)
USBP0+: length 121.6
  TOP w0.127: v1(25.68,48.9) 25.52,49.06 25.07,49.06 24.7,49.43 24.7,50.05 24.54,50.2 24.2,50.2 24.05,50.05 L2.3 23.32,50.05 R161.2
  IN1 w0.102: v1(25.68,48.9) 25.48,49.1 25.16,49.1 24.09,50.17 24.09,54.33 27.09,57.33 27.09,58.8 27.78,59.49 29.25,59.49 32.07,62.3 32.07,70.41 35.55,73.89 40.43,73.89 42.29,72.04 52.73,72.04 61.73,81.04 61.73,84.84 61.26,85.31 61.26,91.16 64.75,94.65 68.59,94.65 68.92,94.32 72.27,94.32 74.53,92.06 75.21,92.06 75.22,92.05 81.59,92.05 81.75,91.88 82.6,91.88 83.04,92.31 87.16,92.31 87.69,91.79 90.72,91.79 91.84,92.91 93.37,92.91 95.4,90.87 96.4,90.87 96.74,90.54 96.74,89.42 96.81,89.35 96.96,89.2 99.65,89.2 99.69,89.24 100.11,89.24 100.23,89.36 100.23,89.57 100.14,89.65 v1(99.99,89.65)
  BOTTOM w0.127: U21.V12 99.64,90 99.99,89.65 v1(99.99,89.65)
USBP0+_R: length 10.1
  TOP w0.127: R161.1 22.33,50.05 L2.4 21.72,50.05 21.44,50.33 21.29,50.33 21.09,50.14 21.09,49.16 20.46,48.53 19.13,48.53 ESD3.7 18.84,48.53 18.29,48.53 18.23,48.47 16.75,48.47 16.6,48.32 16.6,47.93 16.42,47.75 16.42,47.61 15.94,47.13 15.72,47.13 15.59,47 CN8.3
USBP0-: length 121.6
  TOP w0.127: R158.2 23.32,50.85 L2.2 24.01,50.85 24.4,50.46 24.65,50.46 24.95,50.15 24.95,49.54 25.18,49.31 25.52,49.31 25.68,49.48 v1(25.68,49.56)
  IN1 w0.102: v1(25.68,49.56) 25.68,49.47 25.51,49.3 25.25,49.3 24.29,50.25 24.29,54.24 27.29,57.24 27.29,58.72 27.86,59.29 29.34,59.29 32.27,62.22 32.27,70.32 35.64,73.69 40.35,73.69 42.2,71.84 52.82,71.84 61.93,80.95 61.93,84.92 61.46,85.39 61.46,91.07 64.83,94.44 68.51,94.44 68.84,94.11 72.19,94.11 74.45,91.85 81.51,91.85 81.67,91.69 82.68,91.69 83.12,92.12 87.08,92.12 87.61,91.6 90.79,91.6 91.92,92.72 93.29,92.72 95.32,90.68 96.32,90.68 96.55,90.46 96.55,89.34 96.68,89.21 96.88,89.01 99.73,89.01 99.77,89.05 100.19,89.05 100.42,89.28 100.42,89.52 100.49,89.6 v1(100.75,89.6)
  BOTTOM w0.127: v1(100.75,89.6) 100.35,89.99 U21.V10
USBP0-_R: length 10.1
  TOP w0.127: CN8.2 15.59,47.51 15.71,47.39 15.83,47.39 16.17,47.72 16.17,47.86 16.34,48.03 16.34,48.42 16.64,48.72 17.12,48.72 ESD3.4 17.24,48.72 18.12,48.72 18.18,48.78 20.36,48.78 20.84,49.26 20.84,50.24 21.18,50.59 21.44,50.59 21.7,50.85 L2.1 22.33,50.85 R158.1
USBP1+: length 115.5
  TOP w0.102: CN1.A6 8.57,86.05 v1(8.91,85.71)
  TOP w0.127: v1(20.32,89.19) 20.32,89.36 20.15,89.53 19.52,89.53 18.95,90.11 18.49,90.11 18.35,89.96 18.35,89.51 ESD1.1 18.35,89.12 18.35,87.81 19.01,87.15 19.01,85.33 19.3,85.04 19.3,84.16 19.04,83.9 18.76,83.9 v1(18.58,83.72)
  IN1 w0.102: v1(97.15,89.66) 97.42,89.66 97.51,89.75 97.51,89.78 97.73,90 97.73,90.54 96.19,92.08 96.19,92.76 96.18,92.77 96.18,93.54 94.12,95.6 93.76,95.6 92.89,96.47 89.21,96.47 88.6,97.09 77.35,97.09 77.03,97.41 76.36,97.41 76.03,97.08 72.49,97.08 70.85,95.44 64.85,95.44 61.25,91.85 43.91,91.85 42.76,93 25.66,93 22.33,89.67 20.6,89.67 20.47,89.54 20.39,89.54 20.32,89.47 v1(20.32,89.19) ; v1(8.91,85.71) 9.11,85.92 9.11,86.06 8.99,86.18 8.34,86.18 7.92,85.76 6.31,85.76 CN1.B6
  IN3 w0.127: v1(8.91,85.71) 9.14,85.49 9.14,85.3 9.49,84.94 10.28,84.94 11.78,86.44 13.72,86.44 15.38,84.79 16.39,84.79 17.28,83.9 18.4,83.9 v1(18.58,83.72)
  BOTTOM w0.102: U21.V16 97.35,90.19 97.1,90.19 96.96,90.04 96.96,89.85 v1(97.15,89.66)
USBP1-: length 115.5
  TOP w0.102: CN1.A7 7.65,85.55 7.95,85.85 8.2,85.85 8.74,85.31 9.16,85.31 v1(9.57,85.71)
  TOP w0.127: v1(20.3,89.95) 20.14,89.78 19.63,89.78 19.05,90.36 18.38,90.36 18.09,90.07 18.09,87.71 18.75,87.05 18.75,86.52 ESD1.6 18.75,86.1 18.75,85.22 19.04,84.93 19.04,84.27 18.93,84.16 18.8,84.16 v1(18.58,84.38)
  IN1 w0.102: CN1.B7 6.18,85.97 7.84,85.97 8.26,86.38 9.07,86.38 9.32,86.14 9.32,85.91 9.51,85.71 v1(9.57,85.71) ; v1(20.3,89.95) 20.38,89.87 22.24,89.87 25.57,93.2 42.85,93.2 43.99,92.05 61.17,92.05 64.76,95.65 70.77,95.65 72.4,97.28 75.95,97.28 76.28,97.61 77.12,97.61 77.43,97.3 88.68,97.3 89.3,96.68 92.97,96.68 93.85,95.8 94.2,95.8 96.38,93.63 96.38,92.16 97.92,90.61 v1(97.92,89.61)
  IN3 w0.127: v1(9.57,85.71) 9.39,85.53 9.39,85.4 9.6,85.2 10.17,85.2 11.67,86.7 13.83,86.7 15.48,85.04 16.5,85.04 17.39,84.16 18.36,84.16 v1(18.58,84.38)
  BOTTOM w0.102: U21.V15 97.99,90.03 97.92,89.96 v1(97.92,89.61)
USBP2+: length 195.3
  TOP w0.127: v1(220.38,16.33) 220.38,16.06 220.18,15.86 L7.2 220.18,15.05 R272.2
  IN3 w0.089: v1(99.34,89.62) 99.09,89.62 98.97,89.73 98.97,90.15 99.65,90.82 104.41,90.82 104.45,90.79 104.47,90.79
  IN3 w0.127: v1(220.38,16.33) 220.59,16.33 220.66,16.4 220.66,17.66 221.58,18.58 223.45,18.58 225.8,20.93 225.8,25.42 225.62,25.6 225.62,26.76 222.5,29.88 215.88,29.88 215.34,30.41 214,30.41 210.97,33.44 207.69,33.44 206.91,34.22 206.44,34.22 206.01,34.65 206.01,35.28 205.71,35.58 203.83,35.58 200.12,39.29 196.19,39.29 194.71,37.82 194.71,34.11 189.29,28.69 184.15,28.69 172.08,40.76 155.79,40.76 154.8,41.75 153.41,41.75 150.13,45.03 148.78,45.03 148.35,45.46 140.86,45.46 140.36,45.97 136.76,45.97 132.23,50.49 130.2,50.49 123.6,57.09 123.6,76.45 119.46,80.59 119.46,84.04 114.56,88.94 109.07,88.94 107.23,90.79 104.47,90.79
  BOTTOM w0.102: v1(99.34,89.62) 99.07,89.62 98.93,89.48 U21.Y13
USBP2+_R: length 16.3
  TOP w0.127: v1(215.34,19.21) 215.35,19.19 215.35,17.1 214.94,16.7 214.94,16.24 214.67,15.97 214.67,15.32 ESD5.4 214.67,14.84 214.67,13.76 214.78,13.64 v1(215.59,13.64) 215.11,13.16 215.11,12.97 215.43,12.65 220.63,12.65 220.73,12.75 220.73,12.87 220.18,13.41 L7.1 220.18,14.05 R272.1
  BOTTOM w0.127: CN17.18 215.35,18.9 215.34,18.92 v1(215.34,19.21)
USBP2-: length 195.3
  TOP w0.127: R273.2 220.98,15.05 L7.3 220.98,16.21 v1(221.1,16.33)
  IN3 w0.089: 104.47,91.04 104.45,91.04 104.41,91 99.57,91 98.79,90.22 98.79,89.88 v1(98.57,89.65)
  IN3 w0.127: 104.47,91.04 107.33,91.04 109.18,89.2 114.67,89.2 119.71,84.15 119.71,80.69 123.85,76.55 123.85,57.2 130.31,50.75 132.33,50.75 136.86,46.22 140.47,46.22 140.97,45.72 148.46,45.72 148.89,45.28 150.24,45.28 153.52,42 154.9,42 155.89,41.01 172.18,41.01 184.26,28.94 189.18,28.94 194.46,34.21 194.46,37.93 196.08,39.55 200.22,39.55 203.94,35.83 205.81,35.83 206.26,35.39 206.26,34.76 206.54,34.47 207.01,34.47 207.79,33.69 211.08,33.69 214.1,30.67 215.45,30.67 215.98,30.14 222.61,30.14 225.88,26.87 225.88,25.7 226.06,25.52 226.06,20.83 223.55,18.32 221.69,18.32 220.91,17.55 220.91,16.52 v1(221.1,16.33)
  BOTTOM w0.102: v1(98.57,89.65) 98.93,90.02 U21.V13
USBP2-_R: length 16.4
  TOP w0.127: v1(214.68,19.21) 215.1,18.79 215.1,18.27 ESD5.3 215.1,17.89 215.1,17.21 214.69,16.8 214.69,16.35 214.41,16.07 214.41,13.65 214.69,13.37 v1(214.69,12.75) 214.97,12.75 215.32,12.4 220.73,12.4 220.98,12.64 L7.4 220.98,14.05 R273.1
  BOTTOM w0.127: CN17.19 214.85,19.03 v1(214.68,19.21)
USBP3+: length 177.3
  TOP w0.127: v1(217.94,16.83) 218.21,16.56 L6.2 218.21,15.56 R270.2
  IN3 w0.089: 104.47,90.11 104.46,90.11 104.41,90.11 104.19,90.34 102.01,90.34 101.73,90.06 101.73,89.63 101.68,89.57 v1(101.42,89.57)
  IN3 w0.127: 104.47,90.11 105.59,88.99 105.59,87.62 105.91,87.3 108.45,87.3 108.86,86.89 109.79,86.89 110.3,87.41 113.94,87.41 117.91,83.44 117.91,78.14 122.05,74 122.05,56.18 122.12,56.1 130.05,48.18 132.35,48.18 136.97,43.56 142.24,43.56 142.63,43.94 146.48,43.94 147.59,42.83 150.16,42.83 152.77,40.21 154.18,40.21 155.16,39.24 169.14,39.24 181.21,27.16 191.17,27.16 195.51,31.5 196.43,31.5 198.97,34.04 205.85,34.04 206.21,33.69 206.72,33.69 207.49,32.92 210.59,32.92 211.75,31.76 211.75,26.07 214.46,23.35 214.46,22.69 215.05,22.11 215.05,21.56 216.05,20.56 216.05,17.38 217.1,16.33 218.07,16.33 218.15,16.41 218.15,16.61 v1(217.94,16.83)
  BOTTOM w0.127: v1(101.42,89.57) 101.42,89.61 101.07,89.96 U21.V9
USBP3+_R: length 10.6
  TOP w0.127: R270.1 218.21,14.56 L6.1 218.21,13.68 218.08,13.55 217.56,13.55 217.27,13.84 217.27,16 216.59,16.68 216.59,17.87 ESD5.1 216.59,18.3 216.59,18.68 216.7,18.78 217.21,18.78 217.43,18.56 217.64,18.56 217.76,18.68 217.76,18.89 v1(217.43,19.22)
  BOTTOM w0.127: v1(217.43,19.22) 217.35,19.14 CN17.14
USBP3-: length 177.4
  TOP w0.127: v1(218.6,16.83) 219.01,16.42 L6.3 219.01,15.56 R271.2
  IN3 w0.089: 104.29,89.93 104.28,89.94 104.28,89.99 104.12,90.16 102.08,90.16 101.91,89.99 101.91,89.84 v1(102.13,89.61)
  IN3 w0.127: 104.29,89.93 105.34,88.88 105.34,87.52 105.81,87.05 108.35,87.05 108.76,86.64 109.89,86.64 110.41,87.15 113.83,87.15 117.66,83.33 117.66,78.03 121.8,73.89 121.8,56.07 129.94,47.92 132.25,47.92 136.87,43.3 142.35,43.3 142.73,43.69 146.37,43.69 147.48,42.58 150.05,42.58 152.67,39.96 154.07,39.96 155.05,38.98 169.03,38.98 181.11,26.91 191.28,26.91 195.62,31.25 196.54,31.25 199.08,33.79 205.75,33.79 206.1,33.43 206.62,33.43 207.38,32.67 210.48,32.67 211.49,31.66 211.49,25.96 214.21,23.24 214.21,22.59 214.79,22 214.79,21.45 215.79,20.45 215.79,17.27 216.99,16.07 218.17,16.07 218.41,16.31 218.41,16.64 v1(218.6,16.83)
  BOTTOM w0.127: U21.V7 101.87,90.03 102.13,89.77 v1(102.13,89.61)
USBP3-_R: length 10.5
  TOP w0.127: R271.1 219.01,14.56 L6.4 219.01,13.8 218.51,13.3 217.45,13.3 217.01,13.74 217.01,14.87 ESD5.6 217.01,15.29 217.01,15.89 216.34,16.57 216.34,18.79 v1(216.77,19.22)
  BOTTOM w0.127: v1(216.77,19.22) 216.85,19.13 CN17.15
USBP4+: length 96.1
  IN3 w0.089: v1(101.28,88.69) 101.15,88.69 101.03,88.56 101.03,88.4 101.15,88.28 103.07,88.28 103.1,88.25 103.85,88.25 104.21,87.88 104.21,87.51 104.25,87.47 104.25,87.46
  IN3 w0.127: v1(145.5,43.1) 145.67,42.92 145.67,42.72 145.35,42.39 137.04,42.39 134.95,44.49 130.35,44.49 129.14,45.7 120.7,45.7 120.1,46.29 120.1,73.75 116.36,77.49 116.36,82.02 112.64,85.74 110.76,85.74 110.4,85.39 105.74,85.39 104.25,86.87 104.25,87.46
  BOTTOM w0.102: v1(101.28,88.69) 101.47,88.88 101.47,88.99 101.27,89.19 101.11,89.19 U21.Y9
  BOTTOM w0.127: CN9.3 152.39,43.75 152.27,43.63 152.18,43.63 152.11,43.7 152.11,44.89 151.41,45.59 146.93,45.59 145.69,44.35 145.69,43.3 v1(145.5,43.1)
USBP4-: length 96.1
  IN3 w0.089: v1(100.57,88.66) 100.85,88.38 100.85,88.32 101.07,88.1 103,88.1 103.03,88.07 103.77,88.07 104.04,87.8 104.04,87.51 104,87.47 104,87.46
  IN3 w0.127: v1(146.16,43.1) 145.93,42.88 145.93,42.61 145.45,42.14 136.93,42.14 134.84,44.23 130.25,44.23 129.03,45.44 120.59,45.44 119.85,46.18 119.85,73.65 116.11,77.39 116.11,81.91 112.53,85.49 110.86,85.49 110.51,85.13 105.63,85.13 104,86.77 104,87.46
  BOTTOM w0.102: v1(100.57,88.66) 100.57,88.83 100.35,89.05 U21.Y10
  BOTTOM w0.127: v1(146.16,43.1) 145.95,43.31 145.95,44.24 147.04,45.33 151.3,45.33 151.85,44.78 151.85,43.59 152.07,43.37 152.28,43.37 152.41,43.25 CN9.5
USBP5+: length 60
  TOP w0.089: 104.25,89.82 104.25,89.8 104.21,89.76 104.21,89.39 103.88,89.06 102.91,89.06 102.8,88.95 v1(102.8,88.72)
  TOP w0.127: v1(61.95,112.6) 62.09,112.45 65.01,112.45 66.28,111.18 68.49,111.18 71.94,107.73 73.57,107.73 75.8,105.5 86.11,105.5 87.4,104.2 92.52,104.2 94.71,102.01 95.41,102.01 96.06,101.36 97.01,101.36 98.92,99.44 98.92,98.62 99.65,97.89 101.41,97.89 101.9,97.4 102.54,97.4 104.25,95.69 104.25,89.82
  BOTTOM w0.102: U21.AB6 102.8,88.51 v1(102.8,88.72)
  BOTTOM w0.127: CN3.5 61.1,112.45 61.22,112.33 61.68,112.33 v1(61.95,112.6)
USBP5-: length 60
  TOP w0.089: v1(102.09,88.72) 102.6,89.24 103.81,89.24 104.03,89.46 104.03,89.76 103.99,89.8 103.99,89.82
  TOP w0.127: v1(61.95,111.94) 62.21,112.2 64.9,112.2 66.17,110.93 68.39,110.93 71.84,107.48 73.46,107.48 75.7,105.24 86,105.24 87.3,103.95 92.41,103.95 94.61,101.75 95.31,101.75 95.96,101.1 96.9,101.1 98.67,99.33 98.67,98.51 99.54,97.64 101.3,97.64 101.8,97.14 102.43,97.14 103.99,95.58 103.99,89.82
  BOTTOM w0.102: v1(102.09,88.72) 102.09,88.36 101.92,88.2 U21.AB7
  BOTTOM w0.127: v1(61.95,111.94) 61.81,112.08 61.26,112.08 61.13,111.95 CN3.4
USBP6+: length 77.7
  TOP w0.127: v1(100,87.69) 100.11,87.58 100.11,87.15 100.94,86.31 105,86.31 105.37,86.68 107.42,86.68 109.15,88.42 109.15,89.88 108.84,90.2 108.84,95.17 108.13,95.88 108.13,97.3 107.19,98.24 106.79,98.24 105.06,99.97 104.14,99.97 101.59,102.53 99.77,102.53 98.09,104.21 96.97,104.21 96.63,104.55 95.77,104.55 93.57,106.74 88.62,106.74 86.94,108.43 82.25,108.43 81.14,109.54 80.87,109.54 79.89,110.53 73.21,110.53 71.54,112.2 71.54,112.89 69.48,114.94 65.42,114.94 64.99,114.51 64.99,114.2 v1(64.8,114.01)
  BOTTOM w0.102: v1(100,87.69) 99.64,87.33 U21.AC12
  BOTTOM w0.127: CN3.8 61.68,113.95 62.44,113.2 63.11,113.2 D11.2 63.97,113.42 64.72,113.42 64.95,113.65 64.95,113.85 v1(64.8,114.01)
USBP6-: length 77.7
  TOP w0.127: v1(100.71,87.68) 100.59,87.68 100.36,87.46 100.36,87.25 101.05,86.57 104.89,86.57 105.26,86.94 107.31,86.94 108.9,88.52 108.9,89.78 108.58,90.09 108.58,95.07 107.88,95.77 107.88,97.2 107.09,97.99 106.69,97.99 104.95,99.72 104.04,99.72 101.48,102.28 99.67,102.28 97.99,103.95 96.86,103.95 96.52,104.29 95.66,104.29 93.47,106.49 88.52,106.49 86.83,108.17 82.15,108.17 81.03,109.29 80.77,109.29 79.78,110.28 73.1,110.28 71.28,112.09 71.28,112.78 69.38,114.69 65.52,114.69 65.24,114.41 65.24,114.07 65.31,114.01 v1(65.53,114.01)
  BOTTOM w0.102: v1(100.71,87.68) 100.76,87.63 100.76,87.22 100.67,87.13 100.55,87.13 U21.AC10
  BOTTOM w0.127: v1(65.53,114.01) 65.38,114.01 65.21,113.83 65.21,113.55 64.82,113.16 64.39,113.16 D12.2 63.14,112.94 62.33,112.94 61.57,113.7 61.36,113.7 61.12,113.45 CN3.7
USBP7+: length 72.5
  IN3 w0.089: v1(103.56,89.64) 103.98,89.23 104.27,89.23 104.41,89.09 104.46,89.09 104.47,89.08
  IN3 w0.127: v1(121.38,47.27) 121.1,46.99 120.97,46.99 120.87,47.08 120.87,74.08 117.14,77.81 117.14,82.32 115.64,83.82 115.64,84.54 113.53,86.65 110.68,86.65 110.21,86.17 108.55,86.17 108.09,86.64 105.54,86.64 105.28,86.89 105,87.18 105,88.56 104.47,89.08
  BOTTOM w0.102: v1(103.56,89.64) 103.56,89.95 103.49,90.03 U21.V5
  BOTTOM w0.127: v1(121.38,47.27) 121.08,46.97 120.72,46.97 120.21,46.46 120.21,42.23 115.49,37.52 115.49,36.19 115.52,36.17 115.52,35.18 115.04,34.71 U32.15
USBP7-: length 72.5
  IN3 w0.089: 104.29,88.9 104.28,88.92 104.28,88.97 104.2,89.05 103.91,89.05 103.73,89.23 103.32,89.23 102.88,89.66 v1(102.84,89.66)
  IN3 w0.127: v1(121.38,46.61) 121.26,46.73 120.86,46.73 120.61,46.98 120.61,73.98 116.88,77.71 116.88,82.22 115.38,83.72 115.38,84.44 113.43,86.39 110.78,86.39 110.31,85.92 108.45,85.92 108.17,86.19 107.98,86.38 105.43,86.38 105.03,86.79 104.74,87.07 104.74,88.45 104.29,88.9
  BOTTOM w0.102: v1(102.84,89.66) 102.49,90.02 U21.V6
  BOTTOM w0.127: v1(121.38,46.61) 121.28,46.72 120.83,46.72 120.47,46.36 120.47,42.13 115.75,37.41 115.75,35.09 115.45,34.79 U32.16
USBPWR1: length 1.5
  TOP w0.203: ESD3.2 17.04,50.38 16.22,49.56 v1(16.22,49.36)
  vias: v1(20.74,53.95) v2(15.38,52.88) v2(15.38,52.12) v2(16.17,52.89) v2(16.19,52.13) v2(22.67,55.14) v2(22.67,54.38) v2(22.67,53.61)
USBPWR2: length 1.5
  TOP w0.508: ESD5.5 215.86,16.14 v1(215.54,16.46)
  vias: v1(221.98,17.86) v1(222.79,16.33) v1(223.02,16.95) v1(223.43,16.43) v1(223.86,16.95) v1(224.06,16.31) v1(224.53,16.76)
VA1: length 30.5
  IN1 w0.508: PJ1.4 223.25,38.96 219.68,35.4 214.72,35.4 212.83,33.51 209.07,33.51 206.93,35.65 203.74,35.65 200.71,38.68 v1(197.73,38.68)
  vias: v1(225.64,38.71) v2(35.33,21.24) v2(36.14,21.27) v2(176,14.7) v2(176.09,13.05) v2(178.23,14.7) v2(178.16,13.15) v2(180.44,14.7) v2(180.51,13.16) v2(223.07,40.21) v2(223.22,42.56) v2(224.59,40.21) v2(224.7,42.5) v2(227.71,42.14) v2(227.68,41.08) v2(228.61,41.07) v2(228.71,42.14) v2(229.18,39.86) v2(229.27,43.34) v2(229.51,42.42) v2(229.51,40.95) v2(229.64,44.23) v2(230.81,43.2) v2(232.34,43.2) v2(232.99,44.33) v2(232.99,43.57)
VA2:
  vias: v1(231.23,36.2) v2(222.85,37.55) v2(224.06,37.55) v2(227.14,37.14) v2(227.19,35.62) v2(228.56,37.09) v2(233.46,37.32) v2(235.85,37.22) v2(237.45,39.83) v2(237.45,38.31)
VDD33/18: length 5.2
  TOP w0.203: U13.27 31.82,34.11 32.86,33.08
  TOP w0.254: C227.2 C226.1 33.72,31.42 v1(32.9,32.24) 32.86,32.29 32.86,33.08
VL: length 31.8
  TOP w0.254: v1(122.95,84.3) 122.95,83.95 126.69,80.2 144.17,80.2 v1(144.55,79.82)
  BOTTOM w0.229: PC162.1 145.25,79.97 144.25,80.97 PU11.15
  BOTTOM w0.254: v1(122.95,84.3) 122.48,83.83 PR159.1 ; v1(144.55,79.82) PC162.1
VNN_ON: length 142.4
  TOP w0.127: PR33.2 119.37,120.6 v1(119.87,121.11)
  TOP w0.14: U16.76 147.94,22.46 147.99,22.52 148.81,22.52 148.87,22.58 151.69,22.58 153.28,24.16 153.28,27.68 153.54,27.94 154.93,27.94 155.31,28.32 155.31,29.34 154.66,29.98 152.33,29.98 148.82,33.49 148.82,40.37 148.32,40.87 148.32,44.25 148,44.57 143.95,44.57 v1(143.4,44.02) 142.8,43.43 139.7,43.43 138.94,44.19 131.37,44.19 v1(130.63,44.93)
  IN1 w0.102: v1(119.87,121.11) 119.87,119.87 118.45,118.44 116.29,118.44 111.61,113.76 111.61,103.42 119.25,95.78 119.25,94.48 122.87,90.86 122.87,86.73 126.06,83.53 126.06,69.86 129.4,66.52 129.4,54.05 131.88,51.57 131.88,49.21 131.03,48.36 131.03,45.33 v1(130.63,44.93)
VNN_SENSE: length 76
  TOP w0.254: PR12.1 113.96,127.67 v1(114.5,127.12)
  IN3 w0.127: v1(82.53,85.77) 83.11,86.35 84.23,86.35 86.29,88.41 86.29,89.53 86.04,89.78 83.8,89.78 82.88,90.7 82.88,95.7 83.68,96.5 83.68,98.8 83.45,99.02 83.45,103.05 82.39,104.11 82.39,108.77 83.14,109.52 83.14,110.99 87.21,115.05 87.21,117.38 88.71,118.88 99.91,118.88 101.38,120.35 101.38,124.33 104.18,127.13 109.23,127.13 110.33,128.23 113.4,128.23 v1(114.5,127.12)
  BOTTOM w0.102: v1(82.53,85.77) 82.53,85.92 U21.AG48
VOUT_BACKLIGHT:
  vias: v1(54.37,113.54) v2(53.37,112.22) v2(53.37,111.46) v2(54.13,112.22) v2(54.13,111.46) v2(59.78,130.43) v2(59.76,129.6) v2(60.63,130.57)
VR_SVID_ALERT#_VCORE: length 37.8
  IN1 w0.102: v1(118.79,123.32) 118.32,122.85 118.32,121.92 118.16,121.75 118.16,119.85 117.94,119.64 115.51,119.64 110.39,114.52 110.39,109.09 109.84,108.54 109.84,107.78 109.71,107.65 108.95,107.65 108.85,107.54 108.85,107.34 108.96,107.22 110.1,107.22 110.22,107.1 110.22,106.93 110.1,106.81 108.96,106.81 108.85,106.69 108.85,106.02 108.96,105.9 109.34,105.9 109.46,105.78 109.46,105.62 109.34,105.5 108.96,105.5 108.85,105.38 108.85,104.97 v1(108.24,104.36)
  BOTTOM w0.127: v1(108.24,104.36) 108.24,103.15 107.49,102.4 106.27,102.4 105.98,102.69 R324.2 105.53,102.88 104.66,102.88 104.45,102.67 R329.1 ; v1(118.79,123.32) 117.92,123.32 117.62,123.01 117.02,123.01 116.96,123.07 PU6.36
