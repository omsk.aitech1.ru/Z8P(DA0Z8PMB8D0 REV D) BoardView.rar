# Allegro board Quanta Z8P DA0Z8PMB8D0 REV D - BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_A_DQ55: length 30.9
  TOP w0.14: v1(76.86,56.28) 77.13,56.28 77.28,56.13 U9.D7
  IN1 w0.102: v1(89.29,79.12) 89.01,79.12 88.94,79.05 88.94,76.6 88.09,75.76 86.64,75.76 86,75.11 86,72.54 85.44,71.99 85.44,69.92 84.87,69.34 84.87,68.18 76.62,59.93 76.62,59.54 77.26,58.89 77.26,57.65 76.86,57.25 v1(76.86,56.28)
  BOTTOM w0.14: U21.BB34 89.72,79.03 89.63,79.12 v1(89.29,79.12)
M_A_DQ56: length 34.8
  IN1 w0.102: v1(77.67,54.65) 78.07,54.25 79.46,54.25 79.7,54.49 79.7,54.85 82.76,57.91 82.76,60.73 82.65,60.84 82.25,60.84 82.12,60.97 82.12,61.17 82.25,61.3 82.65,61.3 82.76,61.41 82.76,61.64 82.65,61.76 82.25,61.76 82.12,61.88 82.12,62.09 82.25,62.21 82.65,62.21 82.76,62.33 82.76,62.58 82.51,62.84 82.51,63.01 82.97,63.48 83.13,63.48 83.36,63.25 83.54,63.25 83.68,63.4 83.68,63.58 83.46,63.8 83.46,63.96 83.62,64.13 83.78,64.13 84.01,63.9 84.19,63.9 84.33,64.04 84.33,64.22 84.1,64.45 84.1,64.61 84.27,64.77 84.43,64.77 84.65,64.55 84.83,64.55 84.98,64.69 84.98,64.87 84.75,65.1 84.75,65.26 84.91,65.42 85.07,65.42 85.3,65.19 85.48,65.19 85.62,65.34 85.62,65.52 85.4,65.74 85.4,65.9 85.56,66.07 85.72,66.07 85.95,65.84 86.13,65.84 86.27,65.98 86.27,66.16 86.04,66.39 86.04,66.55 86.21,66.71 86.37,66.71 86.59,66.49 86.77,66.49 86.92,66.63 86.92,66.81 86.69,67.04 86.69,67.2 86.9,67.4 86.9,69.43 87.43,69.96 87.43,73.44 v1(86.81,74.06)
  BOTTOM w0.102: U21.BJ38 87.31,75.37 87.31,75.05 87.27,75.01 87.27,74.51 v1(86.81,74.06)
  BOTTOM w0.14: v1(77.67,54.65) 78.04,54.28 U25.F2
M_A_DQ57: length 34.3
  IN1 w0.102: v1(76.85,52.25) 76.85,51.65 77.47,51.03 78.88,51.03 80.72,52.87 81.42,52.87 84.96,56.41 84.96,61.68 89.24,65.96 89.24,71.09 v1(88.24,72.08)
  BOTTOM w0.089: v1(88.24,72.08) 89,72.84 89,75.67 89.14,75.81 89.14,76.13 U21.BG34
  BOTTOM w0.14: v1(76.85,52.25) U25.H3
M_A_DQ58: length 33.9
  IN1 w0.102: v1(88.24,70.79) 88.48,70.79 88.66,70.61 88.66,66.2 84.38,61.92 84.38,57.36 84.05,57.03 84.05,56.86 84.24,56.67 84.24,56.51 84.08,56.35 83.92,56.35 83.73,56.54 83.56,56.54 83.4,56.38 83.4,56.22 83.59,56.03 83.59,55.86 83.43,55.7 83.27,55.7 83.08,55.89 82.92,55.89 82.76,55.73 82.76,55.57 82.95,55.38 82.95,55.22 82.79,55.06 82.62,55.06 82.43,55.25 82.27,55.25 79.68,52.66 77.79,52.66 77.67,52.79 v1(77.67,53.07)
  BOTTOM w0.102: U21.BG33 89.74,76.31 89.42,76 89.42,75.78 89.56,75.64 89.56,75.32
  BOTTOM w0.127: 89.56,75.32 89.49,75.24 89.49,72.34 88.66,71.52 88.66,71.21 v1(88.24,70.79)
  BOTTOM w0.14: v1(77.67,53.07) U25.G2
M_A_DQ59: length 34.4
  IN1 w0.102: v1(72.87,52.25) 73.11,52.25 73.52,52.66 74.76,52.66 76.77,53.47 80.08,53.47 84.09,57.48 84.09,62.04 88.24,66.2 v1(88.24,70.14)
  BOTTOM w0.102: U21.BH33 89.77,75.86 89.77,75.23 89.69,75.16 89.69,72.24
  BOTTOM w0.127: v1(88.24,70.14) 88.65,70.54 89.69,72.24
  BOTTOM w0.14: v1(72.87,52.25) 72.87,52.27 U25.H8
M_A_DQ60: length 33.8
  IN1 w0.102: v1(86.81,73.41) 87.22,73 87.22,70.05 86.61,69.45 86.61,67.53 81.83,62.75 81.83,60.55 81.94,60.44 82.36,60.44 82.47,60.32 82.47,60.09 82.36,59.98 81.94,59.98 81.83,59.86 81.83,59.64 81.94,59.52 82.36,59.52 82.47,59.41 82.47,59.18 82.36,59.06 81.94,59.06 81.83,58.95 81.83,58.72 81.94,58.61 82.36,58.61 82.47,58.49 82.47,58.26 82.36,58.15 81.94,58.15 81.83,58.04 81.83,57.42 79.47,55.06 75.4,55.06 74.99,54.65 v1(74.48,54.65)
  BOTTOM w0.102: v1(86.81,73.41) 87.46,74.06 87.46,74.93 87.5,74.97 87.5,75.13 87.7,75.33 87.7,75.65 87.49,75.86 87.49,76.19 U21.BG38
  BOTTOM w0.14: v1(74.48,54.65) 74.45,54.65 U25.F7
M_A_DQ61: length 35.7
  IN1 w0.102: v1(72.87,54.67) 73.27,55.07 74.66,55.07 75.46,55.87 77.12,55.87 77.27,56.02 77.27,56.54 77.42,56.68 79.64,56.68 79.78,56.83 79.78,56.93 79.9,57.04 80.26,57.04 80.38,57.15 80.38,57.38 80.26,57.5 79.9,57.5 79.78,57.61 79.78,57.84 79.9,57.95 80.26,57.95 80.38,58.07 80.38,58.3 80.26,58.41 79.9,58.41 79.78,58.53 79.78,58.75 79.9,58.87 80.26,58.87 80.38,58.98 80.38,59.21 80.26,59.33 79.9,59.33 79.78,59.44 79.78,59.67 79.9,59.78 80.26,59.78 80.38,59.9 80.38,60.13 80.26,60.24 79.9,60.24 79.78,60.35 79.78,60.58 79.9,60.7 80.26,60.7 80.38,60.81 80.38,61.04 80.26,61.15 79.9,61.15 79.78,61.27 79.78,61.53 86.02,67.77 86.02,69.59 86.06,69.63 86.06,71.68 v1(86.81,72.43)
  BOTTOM w0.089: 87.65,74.85 87.68,74.89 87.68,75.05 87.89,75.26 87.89,75.88 U21.BH37
  BOTTOM w0.102: v1(86.81,72.43) 87.65,73.27 87.65,74.85
  BOTTOM w0.14: v1(72.87,54.67) 72.89,54.67 U25.F8
M_A_DQ62: length 34.5
  IN1 w0.102: v1(86.81,71.78) 86.27,71.24 86.27,69.55 86.31,69.5 86.31,67.65 80.67,62 80.67,61.84 80.78,61.73 81.42,61.73 81.54,61.61 81.54,61.39 81.42,61.27 80.78,61.27 80.67,61.16 80.67,60.93 80.78,60.81 81.42,60.81 81.54,60.7 81.54,60.47 81.42,60.36 80.78,60.36 80.67,60.24 80.67,60.01 80.78,59.9 81.42,59.9 81.54,59.78 81.54,59.56 81.42,59.44 80.78,59.44 80.67,59.33 80.67,59.1 80.78,58.98 81.42,58.98 81.54,58.87 81.54,58.64 81.42,58.53 80.78,58.53 80.67,58.41 80.67,58.18 80.78,58.07 81.42,58.07 81.54,57.96 81.54,57.73 81.42,57.61 80.78,57.61 80.67,57.5 80.67,56.99 79.55,55.87 78.07,55.87 v1(77.67,55.47)
  BOTTOM w0.089: U21.BG37 87.88,76.31 88.18,76.02 88.18,75.77 88.07,75.66 88.07,75.19 87.86,74.98 87.86,74.81
  BOTTOM w0.102: 87.86,74.81 87.84,74.78 87.84,72.81 v1(86.81,71.78)
  BOTTOM w0.14: v1(77.67,55.47) U25.E3
M_A_DQ63: length 36.5
  IN1 w0.102: v1(74.48,52.25) 74.63,52.4 76.09,52.4 76.34,52.66 77.13,52.66 77.26,52.53 77.26,52.08 77.5,51.85 79.28,51.85 80.89,53.45 81.07,53.45 81.25,53.27 81.41,53.27 81.57,53.43 81.57,53.59 81.39,53.77 81.39,53.95 81.53,54.1 81.71,54.1 81.9,53.91 82.06,53.91 82.22,54.08 82.22,54.24 82.04,54.42 82.04,54.6 82.18,54.74 82.36,54.74 82.54,54.56 82.7,54.56 84.67,56.53 84.67,61.8 88.95,66.08 88.95,70.73 v1(88.24,71.44)
  BOTTOM w0.127: v1(88.24,71.44) 89.27,72.46 89.27,75.48 U21.BJ34
  BOTTOM w0.14: v1(74.48,52.25) 74.48,52.28 U25.H7
M_A_DQS0: length 48.3
  IN3 w0.102: v1(58.4,54.18) 58.4,53.89 58.29,53.78 53.67,53.78 53.42,54.03 53.42,54.04 53.41,54.05
  IN3 w0.114: 53.41,54.05 52.1,55.36 52.1,63.18 64.91,75.99 65.22,75.99 65.34,75.87 65.34,75.52 65.2,75.39 v1(64.93,75.39)
  BOTTOM w0.102: 74.44,78.78 74.47,78.78 74.51,78.74 74.93,78.74 75.1,78.57 75.25,78.57 U21.BB63
  BOTTOM w0.114: 74.44,78.78 74,78.78 72.87,77.65 70.59,77.65 69.17,76.23 65.69,76.23 65.32,75.85 65.32,75.59 65.11,75.39 v1(64.93,75.39)
  BOTTOM w0.14: U24.F3 59.37,54.06 59.12,53.81 58.47,53.81 58.4,53.88 v1(58.4,54.18)
M_A_DQS1: length 36
  IN3 w0.102: 71.48,76.99 71.5,76.99 71.51,77 72,77 76.41,81.41 76.81,81.41 76.9,81.32 v1(76.9,81.2) ; v1(57.06,56.69) 57.06,56.89 57.17,57 57.54,57 57.84,57.3 57.84,58.86 57.85,58.86 57.85,58.92 57.86,58.93 57.86,59.07 57.94,59.16
  IN3 w0.114: 57.94,59.16 59.53,60.74 59.53,65.04 71.48,76.99
  BOTTOM w0.102: v1(57.06,56.69) 57.06,56.82 56.69,57.19 56.38,57.19 56.17,56.98 U24.C7
  BOTTOM w0.14: U21.AT59 76.9,81.35 v1(76.9,81.2)
M_A_DQS2: length 45.9
  TOP w0.14: U8.F3 56.17,54 56.34,53.83 57.29,53.83 57.58,53.54 57.58,53.16 57.67,53.07 v1(57.85,53.07)
  IN1 w0.089: v1(57.85,53.07) 57.65,53.07 57.56,53.15 57.56,53.57 57.25,53.88 53.65,53.88 52.81,54.71 52.81,59.12 53.34,59.65 53.36,59.65 53.37,59.66
  IN1 w0.102: 53.37,59.66 62.87,69.16 64.21,69.16 73.61,78.56 76.73,78.56 v1(76.94,78.35)
  BOTTOM w0.102: U21.BB59 77.21,78.79 77.21,78.47 77.09,78.35 v1(76.94,78.35)
M_A_DQS3: length 37.8
  TOP w0.102: U8.C7 59.08,56.97 58.58,56.97 v1(58.36,56.75)
  IN1 w0.089: v1(58.36,56.75) 58.14,56.97 57.99,56.97 57.7,57.26 57.7,58.41 59.11,59.82 59.11,59.83 59.12,59.85
  IN1 w0.102: v1(80.14,78.46) 80.31,78.63 80.49,78.63 80.58,78.55 80.58,77.61 80.73,77.45 80.73,76.77 79.7,75.74 79.38,75.74 78.48,74.84 78.48,74.51 77.79,73.82 74.6,73.82 72.13,71.35 72.13,70.27 63.67,61.8 62.65,61.8 61.37,60.52 59.79,60.52 59.12,59.85
  BOTTOM w0.102: U21.BD52 80.5,78.1 v1(80.14,78.46)
M_A_DQS4: length 37.8
  TOP w0.14: U9.F3 74.3,54.06 74.78,54.06 v1(74.95,54.23)
  IN3 w0.102: 80.51,54.53 80.49,54.51 80.49,54.5 79.76,53.77 76.14,53.77 75.83,54.07 75.1,54.07 v1(74.95,54.23)
  IN3 w0.114: v1(86.39,80.57) 86.39,80.55 85.71,79.87 85.71,78.98 86.15,78.55 86.15,76.64 87.58,75.21 87.58,70 87.34,69.76 87.34,65.5 83.12,61.29 83.12,57.14 80.51,54.53
  BOTTOM w0.102: v1(86.39,80.57) 86.76,80.95 U21.AV39
M_A_DQS5: length 25.4
  IN3 w0.102: 75.93,58.89 75.93,58.87 75.92,58.86 75.92,57.48 75.47,57.04 75.05,57.04 74.91,56.89 v1(74.91,56.75)
  IN3 w0.114: 75.93,58.89 75.93,59.04 83.21,66.32 83.21,70.04 83.41,70.24 83.41,71.13 83.53,71.25 83.66,71.25 v1(83.82,71.09)
  BOTTOM w0.089: U21.BJ42 85.56,75.48 84.99,74.9 84.99,71.93 84.42,71.37 84.1,71.37 v1(83.82,71.09)
  BOTTOM w0.102: U25.C7 74.08,57.01 74.22,57.14 74.6,57.14 74.91,56.84 v1(74.91,56.75)
M_A_DQS6: length 30
  TOP w0.102: U9.C7 77.03,56.93 76.56,56.93 v1(76.39,56.76)
  IN1 w0.089: 75.57,59.35 75.57,59.33 75.58,59.32 75.58,57.29 75.9,56.98 76.16,56.98 v1(76.39,56.76)
  IN1 w0.102: v1(88.32,78.55) 88.14,78.37 87.91,78.37 87.71,78.17 87.71,76.74 87.46,76.5 86.29,76.5 84.77,74.98 84.77,70.35 83.8,69.37 83.8,68.55 75.57,60.32 75.57,59.35
  BOTTOM w0.102: U21.BB35 88.58,78.81 v1(88.32,78.55)
M_A_DQS7: length 33.6
  IN1 w0.089: v1(76.22,54.64) 75.94,54.36 75.94,54.12 76.09,53.97 79.56,53.97 80.17,54.58 80.17,54.6 80.18,54.61
  IN1 w0.102: v1(88.24,74.03) 87.98,73.76 87.83,73.76 87.63,73.56 87.63,69.79 87.53,69.69 87.53,66.49 83.38,62.34 83.38,57.81 80.18,54.61
  BOTTOM w0.089: v1(88.24,74.03) 88.49,73.78 88.57,73.78 88.64,73.86 88.64,75.62 88.51,75.76 U21.BG36
  BOTTOM w0.14: U25.F3 77.28,53.92 77.17,53.82 76.31,53.82 75.97,54.16 75.97,54.55 76.06,54.64 v1(76.22,54.64)
M_A_DQS#0: length 48.3
  IN3 w0.102: 53.27,53.88 53.28,53.88 53.59,53.58 58.21,53.58 v1(58.4,53.39)
  IN3 w0.114: 53.27,53.88 53.25,53.9 51.89,55.27 51.89,63.27 64.82,76.2 65.31,76.2 65.55,75.96 65.55,75.59 v1(65.75,75.39)
  BOTTOM w0.102: 74.39,78.56 74.4,78.56 74.42,78.54 74.87,78.54 75.02,78.38 75.52,78.38 U21.BC62
  BOTTOM w0.114: v1(65.75,75.39) 65.53,75.61 65.53,75.76 65.78,76.01 69.26,76.01 70.68,77.43 72.96,77.43 74.09,78.56 74.39,78.56
  BOTTOM w0.14: U24.G3 59.28,53.57 58.58,53.57 v1(58.4,53.39)
M_A_DQS#1: length 36
  IN3 w0.102: 57.64,59.16 57.64,57.39 57.46,57.2 57.25,57.2 v1(57.06,57.39) ; v1(77.57,81.15) 77.11,81.61 76.33,81.61 71.92,77.2 71.51,77.2 71.5,77.21 71.48,77.21
  IN3 w0.114: 57.64,59.16 59.31,60.83 59.31,65.13 71.39,77.21 71.48,77.21
  BOTTOM w0.102: v1(57.06,57.39) 56.66,57.39 U24.B7
  BOTTOM w0.14: U21.AT58 v1(77.57,81.15)
M_A_DQS#2: length 45.8
  TOP w0.14: U8.G3 56.28,53.59 57.19,53.59 57.33,53.44 57.33,53.24 v1(57.16,53.07)
  IN1 w0.089: 53.27,59.85 53.21,59.79 53.21,59.77 52.64,59.2 52.64,54.64 53.57,53.7 57.18,53.7 57.38,53.5 57.38,53.28 v1(57.16,53.07)
  IN1 w0.102: 53.27,59.85 62.79,69.36 64.12,69.36 73.53,78.77 77.18,78.77 v1(77.59,78.35)
  BOTTOM w0.102: U21.BB58 v1(77.59,78.35)
M_A_DQS#3: length 37.9
  TOP w0.102: v1(58.36,57.41) 58.6,57.17 59.07,57.17 U8.B7
  IN1 w0.089: 59.27,59.71 59.25,59.69 59.23,59.69 57.87,58.33 57.87,57.34 58.06,57.15 58.21,57.15 58.36,57.3 v1(58.36,57.41)
  IN1 w0.102: 59.27,59.71 59.88,60.32 61.46,60.32 62.74,61.6 63.75,61.6 72.34,70.18 72.34,71.27 74.69,73.62 77.87,73.62 78.68,74.43 78.68,74.75 79.46,75.53 79.78,75.53 80.94,76.68 80.94,77.54 80.78,77.69 80.78,78.63 80.58,78.83 80.35,78.83 80.29,78.89 v1(80.29,79.12)
  BOTTOM w0.102: U21.BB52 80.6,78.81 v1(80.29,79.12)
M_A_DQS#4: length 37.8
  TOP w0.14: v1(74.95,53.57) 74.7,53.81 74.41,53.81 U9.G3
  IN3 w0.102: 80.66,54.37 80.65,54.36 80.64,54.36 80.59,54.32 79.84,53.56 76.05,53.56 75.74,53.87 75.18,53.87 74.95,53.64 v1(74.95,53.57)
  IN3 w0.114: v1(86.43,79.92) 86.07,79.92 85.93,79.78 85.93,79.07 86.37,78.64 86.37,76.73 87.79,75.3 87.79,69.91 87.56,69.67 87.56,65.41 83.34,61.2 83.34,57.05 80.81,54.53 80.66,54.37
  BOTTOM w0.102: U21.AW39 86.7,80.23 86.43,79.97 v1(86.43,79.92)
M_A_DQS#5: length 25.4
  IN3 w0.102: v1(74.91,57.41) 75.08,57.24 75.39,57.24 75.72,57.57 75.72,58.86 75.71,58.87 75.71,58.89
  IN3 w0.114: v1(83.82,71.73) 83.55,71.46 83.44,71.46 83.19,71.22 83.19,70.33 82.99,70.13 82.99,66.41 75.71,59.13 75.71,58.89
  BOTTOM w0.089: v1(83.82,71.73) 84.01,71.54 84.34,71.54 84.81,72.01 84.81,74.97 85.29,75.46 85.29,75.64 85.56,75.92 U21.BG42
  BOTTOM w0.102: v1(74.91,57.41) 74.84,57.35 74.21,57.35 U25.B7
M_A_DQS#6: length 30.1
  TOP w0.102: v1(76.39,57.42) 76.67,57.13 77.13,57.13 77.28,57.28 U9.B7
  IN1 w0.089: 75.78,59.35 75.78,59.33 75.76,59.32 75.76,57.37 75.97,57.16 76.13,57.16 v1(76.39,57.42)
  IN1 w0.102: 75.78,59.35 75.78,60.23 84,68.46 84,69.29 84.98,70.26 84.98,74.9 86.37,76.29 87.55,76.29 87.91,76.66 87.91,78.09 87.99,78.17 88.19,78.17 88.32,78.04 v1(88.32,77.82)
  BOTTOM w0.102: v1(88.32,77.82) 88.44,77.7 88.69,77.7 88.8,77.82 U21.BD35
M_A_DQS#7: length 33.6
  IN1 w0.089: 80.4,54.54 80.31,54.45 80.29,54.45 79.63,53.79 76.02,53.79 75.76,54.05 75.76,54.44 v1(75.56,54.64)
  IN1 w0.102: v1(88.24,73.38) 88.06,73.56 87.92,73.56 87.83,73.47 87.83,69.7 87.74,69.61 87.74,66.41 83.58,62.25 83.58,57.72 80.4,54.54
  BOTTOM w0.089: v1(88.24,73.38) 88.47,73.61 88.64,73.61 88.82,73.79 88.82,75.71 88.81,75.72 U21.BH35
  BOTTOM w0.14: U25.G3 77.18,53.58 76.21,53.58 75.73,54.06 75.73,54.47 v1(75.56,54.64)
M_A_ODT0: length 42.2
  TOP w0.102: v1(76.01,50.07) 75.61,49.66 75.21,49.66 74.23,50.64 73.41,50.64 U9.K1 ; U8.K1 55.5,50.64 56.33,50.64 57.3,49.66 57.7,49.66 v1(58.11,50.07)
  TOP w0.152: U8.K1 54.14,50.65 53.5,50.65 52.87,51.28 52.87,52.86 v1(52.18,53.55) 51.17,54.56 R152.2
  IN2 w0.102: v1(58.11,50.07) 58.36,50.07 58.6,50.31 61.82,50.31 62.52,51.01 71.58,51.01 72.31,50.28 74.79,50.28 74.98,50.47 75.61,50.47 v1(76.01,50.07)
  BOTTOM w0.102: U24.K1 60.97,50.75 60.69,50.47 60.51,50.47 60.42,50.56 60.42,50.68 60.35,50.75 60.03,50.75 59.95,50.67 59.95,50.53 59.85,50.44 59.69,50.44 59.62,50.51 59.62,50.66 59.53,50.75 59.18,50.75 58.7,50.27 58.31,50.27 v1(58.11,50.07) ; v1(76.01,50.07) 76.22,50.27 76.61,50.27 77.09,50.75 77.44,50.75 77.52,50.66 77.52,50.51 77.6,50.44 77.76,50.44 77.86,50.53 77.86,50.67 77.93,50.75 78.26,50.75 78.32,50.68 78.32,50.56 78.42,50.47 78.6,50.47 78.88,50.75 U25.K1
M_A_RAS#: length 91.5
  TOP w0.102: v1(76.01,50.88) 75.61,51.29 75.04,51.29 74.54,51.78 74.18,51.78 U9.J3 ; v1(58.11,50.88) 57.7,51.29 57.13,51.29 56.64,51.78 56.27,51.78 U8.J3
  IN2 w0.102: v1(76.01,50.88) 76.19,50.88 76.29,50.99 76.29,51.19 76.2,51.29 75.1,51.29 74.52,50.71 72.45,50.71 71.5,51.67 71.03,51.67 70.63,52.08 67.77,52.08 v1(67.63,51.93) 62.81,51.93 61.6,50.71 58.48,50.71 58.31,50.88 v1(58.11,50.88)
  IN3 w0.152: v1(67.63,51.93) 68.03,51.93 68.51,52.4 68.51,57.38 68.35,57.54 68.19,57.54 68.06,57.66 68.06,58.02 68.19,58.15 68.79,58.15 68.92,58.27 68.92,58.63 68.79,58.75 67.91,58.75 67.78,58.88 67.78,59.24 67.91,59.36 68.35,59.36 69.04,60.05 69.04,64.59 72.02,67.57 72.02,70.62 75.95,74.56 76.86,74.56 77.46,73.95 78.18,73.95 78.34,74.12 78.34,74.43 78.62,74.71 79.35,74.71 79.81,74.24 80.06,74.24 80.39,74.57 81.13,74.57 81.6,74.1 v1(81.6,73.35)
  BOTTOM w0.089: U21.BG47 83.29,76.64 83.41,76.52 83.41,76.35 83.23,76.17 83.1,76.17 82.9,75.97 82.9,75.8 83.06,75.64 83.06,75.13 82.98,75.04 82.76,75.04 82.68,74.95 82.68,74.77 82.76,74.68 82.98,74.68 83.06,74.59 83.06,74.42 82.98,74.33 82.68,74.33 82.57,74.22 82.57,74.08 82.68,73.97 82.98,73.97 83.06,73.88 83.06,73.7 82.98,73.62 82.55,73.62 82.44,73.51 82.44,73.36 82.55,73.26 82.98,73.26 83.06,73.17 83.06,72.99 82.98,72.9 82.52,72.9 82.2,73.22 82.05,73.22 81.95,73.11 81.95,72.96 82.36,72.55 82.98,72.55 83.06,72.46 83.06,72.28 82.98,72.19 82.05,72.19 81.72,72.52 81.72,72.78 81.47,73.03 81.47,73.22 v1(81.6,73.35)
  BOTTOM w0.102: U25.J3 77.28,51.59 77.14,51.45 76.91,51.45 76.8,51.56 76.56,51.56 76.4,51.41 76.4,51.29 76.54,51.15 76.54,51.03 76.4,50.88 v1(76.01,50.88) ; v1(58.11,50.88) 58.11,51.32 58.59,51.81 58.76,51.81 59.07,51.5 59.28,51.5 59.37,51.6 U24.J3
  BOTTOM w0.152: v1(67.63,51.93) 67.36,51.66 67.36,47.47 66.26,46.37 66.26,45.71 65.26,44.71 v1(65.26,40.94) R423.2
M_A_WE#: length 93
  TOP w0.102: U8.L3 56.4,50.28 56.51,50.17 56.51,49.94 56.59,49.85 56.83,49.85 56.95,49.73 56.95,49.33 57.18,49.1 57.32,49.1 v1(57.47,49.26) ; U9.L3 74.31,50.28 74.41,50.17 74.41,49.94 74.5,49.85 74.73,49.85 74.86,49.73 74.86,49.33 75.09,49.1 75.23,49.1 v1(75.38,49.26)
  IN2 w0.102: v1(57.47,49.26) 57.88,48.85 63.17,48.85 63.92,49.6 v1(68.87,49.6) 69.07,49.39 69.23,49.39 69.33,49.5 69.33,50.26 69.43,50.36 69.63,50.36 69.73,50.26 69.73,49.5 69.84,49.39 70.04,49.39 70.14,49.5 70.14,50.24 70.24,50.34 70.44,50.34 70.55,50.24 70.55,49.5 70.65,49.39 70.85,49.39 70.95,49.5 70.95,50.24 71.05,50.34 71.26,50.34 71.36,50.24 71.36,49.43 71.73,49.05 75.18,49.05 v1(75.38,49.26)
  IN3 w0.102: 74.88,75.15 75.09,75.15 75.87,75.93 80.4,75.93 81.55,77.09 v1(82.09,77.09)
  IN3 w0.152: v1(68.87,49.6) 68.71,49.75 66.97,49.75 66.84,49.88 66.84,50.26 66.97,50.39 67.59,50.39 67.72,50.52 67.72,50.89 67.59,51.02 66.27,51.02 66.14,51.14 66.14,51.51 66.27,51.64 66.63,51.64 66.76,51.76 66.76,52.12 66.63,52.25 66.3,52.25 66.14,52.4 66.14,52.7 66.3,52.86 66.53,52.86 66.65,52.98 66.65,53.34 66.53,53.47 66.27,53.47 66.14,53.59 66.14,53.95 66.27,54.08 66.63,54.08 66.75,54.2 66.75,54.56 66.63,54.69 66.3,54.69 66.14,54.84 66.14,55.14 66.3,55.3 67.04,55.3 67.16,55.42 67.16,55.78 67.04,55.9 66.3,55.9 66.14,56.06 66.14,56.26 66.77,56.89 66.77,58.06 65.62,59.21 65.62,63.55 68.15,66.08 68.69,66.08 70.64,68.02 70.64,70.9 74.88,75.15
  BOTTOM w0.102: v1(75.38,49.26) 75.79,49.66 76.04,49.66 76.05,49.66 76.12,49.66 77.27,50.28 U25.L3 ; U24.L3 59.36,50.28 58.21,49.66 58.14,49.66 57.88,49.66 v1(57.47,49.26) ; U21.BG48 82.83,76.26 82.95,76.39 82.95,76.96 82.83,77.09 v1(82.09,77.09)
  BOTTOM w0.152: v1(68.87,49.6) 69.59,49.6 70.45,48.74 70.45,47.74 70.87,47.32 70.87,46.21 71.73,45.36 v1(71.73,40.44) 71.73,39.83 R429.2
M_A_ZQ1: length 5.2
  BOTTOM w0.14: R414.2 51.37,50 v1(51.61,50.24) 52,50.63 54.72,50.63 54.88,50.46 55.19,50.46 U24.L8
M_A_ZQ2: length 8.6
  TOP w0.14: U8.L8 60.38,50.49 60.58,50.49 60.76,50.67 61.84,50.67 v1(62.86,51.69) 64.46,53.29 64.46,55.68 R149.2
M_A_ZQ3: length 5.5
  BOTTOM w0.14: R412.2 v1(69.73,51.99) 70.58,51.99 71.94,50.63 72.62,50.63 72.8,50.45 73.1,50.45 U25.L8
M_A_ZQ4: length 5.2
  TOP w0.102: 80.4,50.75 78.88,50.75 78.41,50.28 U9.L8
  TOP w0.14: 80.4,50.75 v1(81.62,50.75) 82.17,50.75 R162.2
M_B_A0: length 86.7
  TOP w0.102: v1(93.29,47.63) 92.88,47.22 92.48,47.22 92.32,47.38 91.92,48.11 U10.N3 ; U11.N3 109.82,48.11 110.23,47.38 110.39,47.22 110.79,47.22 v1(111.19,47.63)
  IN1 w0.127: v1(102.17,72.49) 102.17,72.89 102.5,73.23 104.91,73.23 106.42,71.72 106.42,70.12 106.3,70 105.98,70 105.85,69.87 105.85,69.62 105.98,69.49 106.3,69.49 106.42,69.36 106.42,69.11 106.3,68.98 105.98,68.98 105.85,68.85 105.85,68.6 105.98,68.47 106.3,68.47 106.42,68.35 106.42,68.09 106.3,67.96 105.98,67.96 105.85,67.84 105.85,67.58 105.98,67.46 106.3,67.46 106.42,67.33 106.42,67.08 106.3,66.95 105.98,66.95 105.85,66.82 105.85,66.57 105.98,66.44 106.3,66.44 106.42,66.31 106.42,66.06 106.3,65.93 105.98,65.93 105.85,65.81 105.85,65.55 105.98,65.42 106.3,65.42 106.42,65.3 106.42,65.04 106.3,64.92 105.98,64.92 105.85,64.79 105.85,64.54 105.98,64.41 106.3,64.41 106.42,64.28 106.42,64.03 106.3,63.9 105.98,63.9 105.85,63.77 105.85,63.52 105.98,63.39 106.41,63.39 106.53,63.27 106.53,63.01 106.41,62.88 105.98,62.88 105.85,62.76 105.85,62.5 105.98,62.38 106.4,62.38 106.53,62.25 106.53,62 106.4,61.87 105.98,61.87 105.85,61.74 105.85,60.28 105.36,59.79 105.36,50.16 104.15,48.95 v1(104.15,48.58)
  IN2 w0.102: v1(111.19,47.63) 111.19,47.84 111,48.04 110.39,48.04 110.25,47.9 110.05,47.9 109.97,47.98 109.97,48.36 109.9,48.43 109.66,48.43 109.56,48.32 109.56,47.78 109.46,47.68 109.26,47.68 109.16,47.78 109.16,48.32 109.05,48.43 108.85,48.43 108.75,48.32 108.75,47.78 108.65,47.68 108.44,47.68 108.34,47.78 108.34,48.32 108.24,48.43 108.04,48.43 107.94,48.32 107.94,47.78 107.83,47.68 107.63,47.68 107.53,47.78 107.53,48.13 107.3,48.36 106.75,48.36 106.52,48.58 v1(104.15,48.58) 101.34,48.58 101.1,48.34 99.61,48.34 98.53,47.26 93.66,47.26 v1(93.29,47.63)
  BOTTOM w0.089: 101.31,73.23 100.89,73.65 100.89,75.45 100.58,75.76 100.58,76.04 100.73,76.19 100.98,76.19 101.04,76.25 101.04,76.46 U21.BG9
  BOTTOM w0.102: 101.31,73.23 102.05,72.49 v1(102.17,72.49) ; v1(93.29,47.63) 93.11,47.46 93.11,47.34 93.24,47.21 93.53,47.21 93.72,47.41 93.72,48.02 94.38,48.68 U26.N3 ; v1(111.19,47.63) 111.02,47.46 111.02,47.34 111.15,47.21 111.44,47.21 111.63,47.41 111.63,48.02 112.29,48.68 U27.N3
  BOTTOM w0.152: v1(104.15,48.58) 103.41,47.84 103.41,45.78 104.26,44.93 v1(104.26,41.38) 104.26,40.23 R439.2
M_B_A1: length 84.5
  TOP w0.102: v1(92.6,46) 93.01,45.6 93.4,45.6 93.64,45.84 93.64,46.51 U10.P7 ; v1(110.51,46) 110.91,45.6 111.31,45.6 111.55,45.84 111.55,46.51 U11.P7
  TOP w0.152: v1(104.01,46.12) 104.01,44.48 104.99,43.5 104.99,40 R200.2
  IN2 w0.102: v1(110.51,46) 110.46,46 110.12,45.67 109.86,45.67 109.76,45.57 109.76,45.32 109.64,45.21 109.48,45.21 109.36,45.32 109.36,45.57 109.26,45.67 109.05,45.67 108.95,45.57 108.95,45.31 108.83,45.19 108.66,45.19 108.54,45.31 108.54,45.57 108.44,45.67 108.24,45.67 108.14,45.57 108.14,45.31 108.02,45.19 107.85,45.19 107.73,45.31 107.73,45.57 107.63,45.67 107.43,45.67 107.32,45.57 107.32,45.31 107.21,45.19 107.04,45.19 106.92,45.31 106.92,45.57 106.82,45.67 106.61,45.67 106.51,45.57 106.51,45.31 106.39,45.19 106.22,45.19 106.11,45.31 106.11,45.57 106,45.67 105.8,45.67 105.7,45.57 105.7,45.31 105.58,45.19 105.41,45.19 105.29,45.31 105.29,45.57 105.19,45.67 104.99,45.67 104.89,45.57 104.89,45.31 104.77,45.19 104.6,45.19 104.48,45.31 104.48,45.64 v1(104.01,46.12) 103.98,46.15 93.95,46.15 93.4,45.6 93.01,45.6 v1(92.6,46)
  IN3 w0.102: 103.82,72.64 103.25,73.21 101.29,73.21 100.97,73.53 100.97,74.43 100.85,74.55 100.68,74.55 v1(100.46,74.33)
  IN3 w0.152: 103.82,72.64 103.92,72.54 103.92,72.13 103.55,71.76 103.55,71.37 103.73,71.2 104.35,71.2 104.5,71.04 104.5,70.74 104.35,70.59 104.21,70.59 104.06,70.43 104.06,70.13 104.21,69.98 104.35,69.98 104.5,69.82 104.5,69.52 104.35,69.37 104.21,69.37 104.06,69.22 104.06,68.91 104.21,68.76 104.35,68.76 104.5,68.61 104.5,68.3 104.35,68.15 104.21,68.15 104.06,68 104.06,67.69 104.21,67.54 104.35,67.54 104.5,67.39 104.5,67.08 104.35,66.93 104.21,66.93 104.06,66.78 104.06,66.47 104.21,66.32 104.35,66.32 104.5,66.17 104.5,65.86 104.35,65.71 104.21,65.71 104.06,65.56 104.06,50.9 104.5,50.46 104.5,49.07 104.61,48.96 104.61,48.39 105.09,47.91 105.09,47.73 104.85,47.49 104.61,47.49 104.18,47.92 104,47.92 103.63,47.56 103.63,47.38 104.01,47 v1(104.01,46.12)
  BOTTOM w0.089: v1(100.46,74.33) 100.07,74.72 100.07,75.12 100.13,75.18 100.13,75.66 100.26,75.8 100.26,76.13 U21.BG10
  BOTTOM w0.102: v1(110.51,46) 110.62,46.11 110.62,46.32 110.53,46.41 110.22,46.41 109.83,46.8 109.83,47.05 109.96,47.18 109.96,47.38 109.7,47.64 109.54,47.64 109.39,47.49 109.12,47.49 108.99,47.62 108.99,47.77 109.1,47.88 U27.P7 ; v1(92.6,46) 92.71,46.11 92.71,46.32 92.62,46.41 92.31,46.41 91.92,46.8 91.92,47.05 92.05,47.18 92.05,47.38 91.79,47.64 91.63,47.64 91.48,47.49 91.22,47.49 91.08,47.62 91.08,47.77 91.19,47.88 U26.P7
M_B_A2: length 85.1
  TOP w0.102: U10.P3 91.35,47.68 91.99,47.04 91.99,46.75 92.33,46.41 92.83,46.41 v1(93.24,46) ; v1(111.14,46) 110.74,46.41 110.24,46.41 109.9,46.75 109.9,47.04 109.26,47.68 U11.P3
  TOP w0.152: v1(104.61,46.69) 104.96,46.33 104.96,44.36 105.47,43.85 v1(105.47,42.13) 105.47,40.53 R201.2
  IN2 w0.102: v1(111.14,46) 112.84,46 112.95,46.12 112.95,46.53 112.83,46.65 111.58,46.65 111.34,46.41 110.22,46.41 110.1,46.3 110.1,46.04 109.93,45.87 105.42,45.87 v1(104.61,46.69) 101.45,46.35 93.58,46.35 v1(93.24,46)
  IN3 w0.102: 104.91,72.75 103.7,73.95 102.8,74.37 102.49,74.37 102.19,74.26 v1(101.47,73.63)
  IN3 w0.152: 104.91,72.75 105.16,72.49 105.16,71.06 105.32,70.91 105.59,70.91 105.75,70.76 105.75,70.45 105.59,70.3 105.32,70.3 105.16,70.15 105.16,69.84 105.32,69.69 105.59,69.69 105.75,69.54 105.75,69.23 105.59,69.08 105.32,69.08 105.16,68.93 105.16,68.62 105.32,68.47 105.59,68.47 105.75,68.32 105.75,68.01 105.59,67.86 105.32,67.86 105.16,67.71 105.16,67.4 105.32,67.25 105.59,67.25 105.75,67.1 105.75,66.79 105.59,66.64 105.32,66.64 105.16,66.49 105.16,66.19 105.32,66.03 105.59,66.03 105.75,65.88 105.75,65.58 105.59,65.42 105.32,65.42 105.16,65.27 105.16,64.97 105.32,64.81 105.59,64.81 105.75,64.66 105.75,64.36 105.59,64.2 105.32,64.2 105.16,64.05 105.16,63.75 105.32,63.59 105.59,63.59 105.75,63.44 105.75,63.14 105.59,62.98 105.32,62.98 105.16,62.83 105.16,62.53 105.32,62.38 105.59,62.38 105.75,62.22 105.75,61.92 105.59,61.77 105.32,61.77 105.16,61.61 105.16,61.31 105.32,61.16 105.59,61.16 105.75,61 105.75,60.7 105.59,60.55 105.32,60.55 105.16,60.39 105.16,59.98 105.32,59.83 105.6,59.83 105.75,59.68 105.75,59.37 105.6,59.22 105.32,59.22 105.16,59.07 105.16,49.34 105.84,48.66 105.84,47.11 105.42,46.69 v1(104.61,46.69)
  BOTTOM w0.102: v1(101.47,73.63) 101.07,74.03 101.07,75.68 U21.BH9 ; U27.P3 112.61,47.88 112.72,47.77 112.72,47.56 112.57,47.41 112.22,47.41 112.02,47.21 112.02,47 111.65,46.64 111.65,46.52 v1(111.14,46) ; U26.P3 94.71,47.88 94.82,47.77 94.82,47.56 94.67,47.41 94.31,47.41 94.11,47.21 94.11,47 93.75,46.64 93.75,46.52 v1(93.24,46)
M_B_A3: length 91.3
  TOP w0.102: v1(93.24,44.38) 92.83,44.79 92.43,44.79 92.22,44.99 91.68,46.41 91.49,46.61 91.35,46.61 91.02,46.94 90.87,48.02 U10.N2 ; v1(111.14,44.38) 110.74,44.79 110.34,44.79 110.13,44.99 109.59,46.41 109.39,46.61 109.26,46.61 108.93,46.94 108.78,48.02 U11.N2
  IN2 w0.102: v1(111.14,44.38) 111.29,44.53 111.29,44.72 111.22,44.79 110.34,44.79 110.14,44.58 109.9,44.58 109.78,44.46 109.78,44.26 109.68,44.16 109.47,44.16 109.37,44.26 109.37,44.48 109.27,44.58 109.07,44.58 108.96,44.48 108.96,44.26 108.86,44.16 108.66,44.16 108.56,44.26 108.56,44.48 108.46,44.58 103.38,44.58 v1(103.07,44.89) 96.76,44.89 96.41,44.54 93.4,44.54 v1(93.24,44.38)
  IN3 w0.14: v1(98.28,77.71) 99.71,75.21 100.03,74.11 101.17,72.97 101.88,72.18 103.3,70.59
  IN3 w0.152: v1(103.07,44.89) 103.17,44.79 105.29,44.79 105.37,44.71 105.37,44.25 105.5,44.12 105.91,44.12 106.04,44.25 106.04,45.37 105.91,45.5 103.67,45.5 103.29,45.88 103.29,47.76 103.59,48.05 103.59,50.86 103.66,50.93 103.66,70.24 103.3,70.59
  BOTTOM w0.102: v1(111.14,44.38) 111.4,44.38 111.65,44.63 111.65,45.61 112.08,46.04 112.08,46.38 112.32,46.61 112.61,46.61 112.93,46.93 112.93,48.35 U27.N2 ; v1(93.24,44.38) 93.49,44.38 93.74,44.63 93.74,45.61 94.18,46.04 94.18,46.38 94.41,46.61 94.7,46.61 95.02,46.93 95.02,48.35 U26.N2 ; U21.BD16 v1(98.28,77.71)
  BOTTOM w0.152: R436.2 100.44,43.26 100.78,43.6 101.77,43.6 v1(103.07,44.89)
M_B_A4: length 95.5
  TOP w0.102: v1(92.6,41.13) 93.01,41.53 93.4,41.53 93.89,42.01 95.18,43.42 95.68,44.69 95.68,47.19 U10.P8 ; U11.P8 113.59,47.19 113.59,44.69 113.08,43.42 111.79,42.01 111.31,41.53 110.91,41.53 v1(110.51,41.13)
  TOP w0.152: R197.2 102.48,40.3 v1(103.03,40.85)
  IN1 w0.102: v1(98.27,78.39) 98.77,77.89 99.68,74.5 101.69,70.79 101.69,70.66
  IN1 w0.127: v1(103.03,40.85) 103.71,43.05 103.71,44.19 103.57,45.97 103.57,46.3 103.62,46.86 103.62,48.03 103.38,49.14 101.89,51.64 101.89,53.44 102.02,53.92 102.3,54.77 102.3,69.43 101.69,70.04 101.69,70.66
  IN2 w0.102: v1(92.6,41.13) 93.01,40.72 102.9,40.72 v1(103.03,40.85) 105.44,40.85 105.54,40.95 105.54,41.07 105.64,41.17 105.84,41.17 105.94,41.07 105.94,40.89 106.06,40.77 106.23,40.77 106.35,40.89 106.35,41.07 106.45,41.17 106.65,41.17 106.76,41.07 106.76,40.89 106.88,40.77 107.04,40.77 107.16,40.89 107.16,41.07 107.26,41.17 107.47,41.17 107.57,41.07 107.57,40.89 107.69,40.77 107.86,40.77 107.98,40.89 107.98,41.07 108.08,41.17 108.28,41.17 108.38,41.07 108.38,40.89 108.5,40.77 108.67,40.77 108.79,40.89 108.79,41.07 108.89,41.17 109.09,41.17 109.19,41.07 109.19,40.88 109.31,40.76 109.48,40.76 109.6,40.88 109.6,41.07 109.7,41.17 109.91,41.17 110.01,41.07 110.01,40.98 110.09,40.89 110.27,40.89 v1(110.51,41.13)
  BOTTOM w0.102: v1(92.6,41.13) 92.37,41.13 91.96,41.53 90.13,45.36 90.13,46.33 90.28,46.48 90.28,46.73 90.13,46.88 90.13,47.13 90.28,47.28 90.28,47.49 90.13,47.64 90.13,47.8 90.21,47.88 U26.P8 ; U27.P8 108.11,47.88 108.04,47.8 108.04,47.64 108.19,47.49 108.19,47.28 108.04,47.13 108.04,46.88 108.19,46.73 108.19,46.48 108.04,46.33 108.04,45.36 109.87,41.53 110.27,41.13 v1(110.51,41.13) ; U21.BB16 v1(98.27,78.39)
M_B_A5: length 95.6
  TOP w0.102: U11.P2 108.13,47.19 108.13,45.39 109.62,42.06 110.14,40.92 110.34,40.72 110.74,40.72 v1(111.14,41.13) ; U10.P2 90.22,47.19 90.22,45.39 91.71,42.06 92.23,40.92 92.43,40.72 92.83,40.72 v1(93.24,41.13)
  TOP w0.152: R196.2 101.46,40.23 v1(102.48,41.25)
  IN1 w0.127: v1(102.48,41.25) 102.48,46.11 103.31,46.95 103.31,47.9 102.97,48.24 102.97,49.06 101.58,50.45 101.58,52.67 101.43,52.83 101,52.83 100.88,52.96 100.88,53.21 101,53.34 101.46,53.34 101.58,53.46 101.58,53.77 101.46,53.89 101.15,53.89 101.03,54.02 101.03,54.33 101.15,54.45 101.59,54.45 102,54.86 102,69.07 101.38,69.69 101.38,70.6 100.64,71.34 v1(100.44,71.34)
  IN2 w0.102: v1(111.14,41.13) 110.74,41.53 110.33,41.53 110.18,41.38 104.98,41.38 104.75,41.15 104.42,41.15 104.19,41.38 103.89,41.38 103.66,41.15 103.31,41.15 103.1,41.36 102.59,41.36 v1(102.48,41.25) 93.36,41.25 v1(93.24,41.13)
  BOTTOM w0.089: U21.BG11 99.93,76.29 99.64,76 99.64,75.75 99.77,75.62 99.77,75.32 99.65,75.2 99.65,74.29 100.42,73.51 100.42,71.36 v1(100.44,71.34)
  BOTTOM w0.102: U26.P2 95.61,47.88 95.77,47.72 95.77,46.04 94.52,42.41 94.28,42.17 94.14,42.17 93.95,42.36 93.78,42.36 93.66,42.24 93.66,42.07 93.9,41.83 93.9,41.55 93.48,41.13 v1(93.24,41.13) ; U27.P2 113.52,47.88 113.68,47.72 113.68,46.04 112.43,42.41 112.19,42.17 112.04,42.17 111.85,42.36 111.69,42.36 111.57,42.24 111.57,42.07 111.81,41.83 111.81,41.55 111.39,41.13 v1(111.14,41.13)
M_B_A6: length 88.7
  TOP w0.102: v1(110.51,42.75) 110.91,42.35 111.31,42.35 111.51,42.54 112.79,45.19 112.94,46.49 U11.R8 ; U10.R8 95.04,46.49 94.88,45.19 93.6,42.54 93.4,42.35 93.01,42.35 v1(92.6,42.75)
  TOP w0.152: R195.2 100.44,41.72 101.24,42.51 v1(101.49,42.51)
  IN1 w0.127: v1(101.49,42.51) 101.49,44.97 101.24,45.22 101.24,46.22 102.26,47.24 102.26,47.61 102.02,47.85 102.02,48.68 99.71,50.99 99.71,65.99 99.85,66.13 100.76,66.13 100.9,66.27 100.9,66.54 100.76,66.68 99.91,66.68 99.78,66.81 99.78,67.12 99.91,67.24 100.76,67.24 100.9,67.38 100.9,67.66 100.76,67.8 99.91,67.8 99.78,67.93 99.78,68.23 99.91,68.36 100.76,68.36 100.9,68.5 100.9,68.78 100.76,68.92 99.83,68.92 99.7,69.05 99.7,69.35 99.83,69.48 100.14,69.48 100.27,69.61 100.27,69.91 100.14,70.04 99.59,70.04 99.42,70.21 99.42,71.88 v1(99.59,72.05)
  IN2 w0.102: v1(110.51,42.75) 110.35,42.6 101.58,42.6 v1(101.49,42.51) 101.33,42.35 93.01,42.35 v1(92.6,42.75)
  BOTTOM w0.089: v1(99.59,72.05) 100.12,72.58 100.12,73.52 99.47,74.17 U21.BJ12
  BOTTOM w0.102: U26.R8 90.55,46.75 91.02,46.28 91.02,45.15 91.12,45.05 91.38,45.05 91.47,44.95 91.47,44.75 91.28,44.55 91.28,44.3 91.61,43.98 91.73,43.98 91.84,44.09 91.98,44.09 92.13,43.95 92.13,43.8 91.98,43.66 91.98,43.35 92.19,43.15 92.49,43.15 92.6,43.04 v1(92.6,42.75) ; v1(110.51,42.75) 110.51,43.04 110.4,43.15 110.09,43.15 109.89,43.35 109.89,43.66 110.03,43.8 110.03,43.95 109.89,44.09 109.75,44.09 109.63,43.98 109.51,43.98 109.19,44.3 109.19,44.55 109.38,44.75 109.38,44.95 109.28,45.05 109.03,45.05 108.93,45.15 108.93,46.28 108.46,46.75 U27.R8
M_B_A7: length 89.1
  TOP w0.102: U10.R2 90.88,46.42 90.88,45.48 91.49,44.11 92.43,43.16 92.83,43.16 v1(93.24,42.75) ; v1(111.14,42.75) 110.74,43.16 110.34,43.16 109.39,44.11 108.79,45.48 108.79,46.42 U11.R2
  TOP w0.152: R194.2 99.43,40.14 99.52,40.24 99.52,41.46 v1(100.99,42.92)
  IN2 w0.102: v1(111.14,42.75) 110.74,43.16 110.34,43.16 110.1,42.92 v1(100.99,42.92) 100.49,42.92 100.24,42.66 100.04,42.66 99.93,42.76 99.93,42.92 99.83,43.02 99.63,43.02 99.53,42.92 99.53,42.75 99.43,42.65 99.22,42.65 99.12,42.75 99.12,42.92 99.02,43.02 98.82,43.02 98.72,42.92 98.72,42.75 98.61,42.65 98.41,42.65 98.31,42.75 98.31,42.92 98.21,43.02 98,43.02 97.9,42.92 97.9,42.75 97.8,42.65 97.6,42.65 97.5,42.75 97.5,42.92 97.39,43.02 97.19,43.02 97.04,42.87 97.04,42.72 96.94,42.62 96.73,42.62 96.63,42.72 96.63,42.9 96.53,43 96.33,43 96.23,42.9 96.23,42.73 96.13,42.63 95.91,42.63 95.78,42.75 v1(93.24,42.75)
  IN3 w0.102: 101.19,67.79 101.19,68.47 98.48,71.18 v1(98.48,72.71)
  IN3 w0.152: 101.19,67.79 101.19,64.09 100.47,63.37 100.47,49.99 101.2,49.26 101.2,48.15 100.99,47.93 100.99,46.93 100.32,46.26 100.32,45.41 100.66,45.06 102.11,45.06 102.22,44.95 102.22,43.12 102.08,42.98 101.79,42.98 101.65,43.11 101.65,43.55 101.48,43.72 99.83,43.72 99.71,43.59 99.71,43.31 99.83,43.19 100.72,43.19 v1(100.99,42.92)
  BOTTOM w0.102: v1(98.48,72.71) 98.07,73.11 98.07,75 98.25,75.18 98.25,75.64 98.37,75.76 98.37,76.09 U21.BG14 ; U26.R2 95.35,46.75 95.02,46.42 95.02,46.16 94.68,45.82 94.68,45.48 94.88,45.28 94.88,45.1 94.19,44.42 94.19,43.49 93.45,42.75 v1(93.24,42.75) ; U27.R2 113.26,46.75 112.93,46.42 112.93,46.16 112.59,45.82 112.59,45.48 112.78,45.28 112.78,45.1 112.1,44.42 112.1,43.49 111.36,42.75 v1(111.14,42.75)
M_B_A8: length 89.7
  TOP w0.102: v1(111.14,41.94) 111.23,41.94 112.15,42.86 112.15,43.38 112.36,43.6 112.54,43.6 112.62,43.51 112.79,43.51 112.95,43.67 112.95,44.03 112.89,44.08 112.72,44.08 112.63,44.17 112.63,44.38 112.74,44.49 113.05,44.49 113.26,44.7 U11.T8 ; v1(93.24,41.94) 93.32,41.94 94.24,42.86 94.24,43.38 94.45,43.6 94.63,43.6 94.72,43.51 94.88,43.51 95.04,43.67 95.04,44.03 94.99,44.08 94.81,44.08 94.72,44.17 94.72,44.38 94.83,44.49 95.14,44.49 95.35,44.7 U10.T8
  IN1 w0.127: v1(99.61,72.69) 99.84,72.69 100.03,72.51 100.03,71.79 99.89,71.65 99.89,70.82 100.49,70.22 100.49,69.62 101.36,68.75 101.36,65.79 101.22,65.65 100.3,65.65 100.16,65.51 100.16,65.23 100.3,65.09 101.05,65.09 101.18,64.96 101.18,64.66 101.05,64.53 100.3,64.53 100.16,64.39 100.16,64.11 100.3,63.97 101.08,63.97 101.21,63.85 101.21,63.54 101.08,63.41 100.3,63.41 100.16,63.27 100.16,63 100.3,62.86 101.08,62.86 101.21,62.73 101.21,62.42 101.08,62.3 100.3,62.3 100.16,62.16 100.16,50.99 102.34,48.81 102.34,47.98 102.58,47.74 102.58,47.11 101.55,46.09 101.55,45.36 102,44.9 v1(102,42.07)
  IN2 w0.102: v1(111.14,41.94) 110.74,42.35 110.34,42.35 110.06,42.07 v1(102,42.07) 98.25,42.07 98.01,41.83 97.56,41.83 97.32,42.07 96.58,42.07 96.34,41.83 95.87,41.83 95.64,42.07 95.08,42.07 94.85,41.84 94.05,41.84 93.82,42.07 93.36,42.07 v1(93.24,41.94)
  BOTTOM w0.089: U21.BG12 99.36,76.15 99.36,75.81 99.2,75.66 99.2,75.31 99.29,75.22 99.29,73.01 v1(99.61,72.69)
  BOTTOM w0.102: v1(93.24,41.94) 92.83,41.53 92.43,41.53 92.18,41.79 91.21,43.94 90.55,45.35 U26.T8 ; U27.T8 108.46,45.35 109.12,43.94 110.08,41.79 110.34,41.53 110.74,41.53 v1(111.14,41.94)
  BOTTOM w0.152: R437.2 102,40.01 v1(102,42.07)
M_B_A9: length 84.8
  TOP w0.102: v1(92.6,45.19) 92.72,45.31 92.72,45.47 92.6,45.6 92.31,45.6 92.18,45.72 92.18,46.26 91.79,46.65 91.79,46.96 91.67,47.08 U10.R3 ; v1(110.51,45.19) 110.63,45.31 110.63,45.47 110.51,45.6 110.22,45.6 110.09,45.72 110.09,46.26 109.7,46.65 109.7,46.96 109.57,47.08 U11.R3
  TOP w0.152: R192.2 97.4,39.85 v1(98.09,40.55) 98.75,41.21 98.75,43.02 101.27,45.54 v1(101.99,45.54)
  IN1 w0.127: v1(100.6,70.72) 100.8,70.52 100.8,69.74 101.68,68.86 101.68,61.88 101.54,61.74 100.63,61.74 100.49,61.6 100.49,61.32 100.63,61.18 101.54,61.18 101.68,61.04 101.68,60.76 101.54,60.62 100.63,60.62 100.49,60.48 100.49,60.2 100.63,60.06 101.43,60.06 101.56,59.94 101.56,59.63 101.43,59.5 100.63,59.5 100.49,59.36 100.49,59.08 100.63,58.95 101.46,58.95 101.59,58.82 101.59,58.51 101.46,58.39 100.63,58.39 100.49,58.25 100.49,57.97 100.63,57.83 101.48,57.83 101.61,57.7 101.61,57.4 101.48,57.27 100.63,57.27 100.49,57.13 100.49,56.85 100.63,56.71 101.46,56.71 101.59,56.58 101.59,56.28 101.46,56.15 100.63,56.15 100.49,56.01 100.49,55.73 100.63,55.59 101.41,55.59 101.54,55.47 101.54,55.16 101.41,55.03 100.63,55.03 100.49,54.89 100.49,51.11 102.66,48.94 102.66,48.11 102.98,47.79 102.98,47.06 101.99,46.07 v1(101.99,45.54)
  IN2 w0.102: v1(110.51,45.19) 110.22,45.19 109.82,44.79 104.42,44.79 103.98,45.22 103.84,45.22 103.65,45.03 103.5,45.03 103.36,45.18 103.36,45.32 103.55,45.51 103.55,45.65 103.46,45.74 102.19,45.74 v1(101.99,45.54) 101.66,45.2 96.78,45.2 96.36,44.79 93.01,44.79 v1(92.6,45.19)
  BOTTOM w0.089: 100.63,73.58 99.83,74.37 99.83,75.14 99.95,75.25 99.95,75.87 U21.BH11
  BOTTOM w0.102: U27.R3 112.46,47.04 111.92,46.5 111.47,45.76 111.31,45.6 110.91,45.6 v1(110.51,45.19) ; 100.63,73.58 100.89,73.31 100.89,71.01 v1(100.6,70.72) ; U26.R3 94.55,47.04 94.02,46.5 93.57,45.76 93.4,45.6 93.01,45.6 v1(92.6,45.19)
M_B_A10: length 87.6
  TOP w0.102: U11.L7 112.34,50.39 111.8,50.39 111.66,50.25 111.66,50.13 111.95,49.84 111.95,49.54 111.83,49.43 111.64,49.43 111.51,49.55 111.34,49.55 111.19,49.41 v1(111.19,49.26) ; v1(93.29,49.26) 93.29,49.41 93.43,49.55 93.78,49.55 93.94,49.71 93.94,49.88 93.69,50.13 93.69,50.3 93.79,50.39 94.07,50.39 94.23,50.54 94.48,50.54 94.55,50.47 U10.L7
  IN1 w0.127: v1(102.75,72.79) 102.75,72.22 103.11,71.85 104.93,71.85 105.24,71.54 105.24,67.73 105.12,67.61 104.55,67.61 104.42,67.48 104.42,67.23 104.55,67.1 105.12,67.1 105.24,66.97 105.24,66.72 105.12,66.59 104.52,66.59 104.4,66.46 104.4,66.21 104.52,66.08 105.12,66.08 105.24,65.96 105.24,65.7 105.12,65.58 104.5,65.58 104.37,65.45 104.37,65.19 104.5,65.07 105.12,65.07 105.24,64.94 105.24,64.69 105.12,64.56 104.5,64.56 104.37,64.43 104.37,64.18 104.5,64.05 105.12,64.05 105.24,63.92 105.24,63.67 105.12,63.54 104.42,63.54 104.3,63.42 104.3,63.16 104.42,63.04 105.12,63.04 105.24,62.91 105.24,62.65 105.12,62.53 104.42,62.53 104.3,62.4 104.3,62.15 104.42,62.02 105.12,62.02 105.24,61.89 105.24,61.64 105.12,61.51 104.08,61.51 103.95,61.38 103.95,61.13 104.08,61 105.12,61 105.24,60.88 105.24,60.62 105.12,60.5 104.11,60.5 103.95,60.33 103.95,51.34 103.77,51.15 103.77,50.53 v1(104.05,50.25)
  IN2 w0.102: 111.52,49.66 110.25,49.66 110.16,49.58 110.16,49.36 110.09,49.28 109.91,49.28 109.83,49.36 109.83,49.75 109.71,49.87 109.54,49.87 109.42,49.75 109.42,49.38 109.32,49.28 109.12,49.28 109.02,49.38 109.02,49.55 108.9,49.67 108.73,49.67 108.61,49.55 108.61,49.38 108.5,49.27 107.85,49.27 107.49,49.62 107.49,49.7 106.59,50.6 104.4,50.6 v1(104.05,50.25) 99.46,50.25 98.31,49.1 93.45,49.1 v1(93.29,49.26)
  IN2 w0.14: v1(111.19,49.26) 111.31,49.14 111.67,49.14 111.8,49.27 111.8,49.56 111.69,49.66 111.52,49.66
  BOTTOM w0.089: 102.66,72.88 101.95,73.59 101.95,74.36 102.24,74.65 102.24,74.92 101.96,75.21 101.96,75.68 101.83,75.82 101.52,75.82 101.45,75.89 101.45,75.98 101.61,76.14 101.61,76.46 U21.BG7
  BOTTOM w0.102: v1(102.75,72.79) 102.66,72.88 ; v1(111.19,49.26) 110.79,48.85 110.39,48.85 110.25,48.99 U27.L7 ; U26.L7 92.35,48.99 92.48,48.85 92.88,48.85 v1(93.29,49.26)
  BOTTOM w0.152: R442.2 v1(106.54,42.28) 106.54,46.1 106.03,46.61 106.03,47.6 105.65,47.98 105.65,48.67 104.07,50.25 v1(104.05,50.25)
M_B_A11: length 87
  TOP w0.102: U10.R7 93.87,46.4 93.87,44.98 93.67,44.79 93.24,44.79 93.11,44.91 93.11,45.07 v1(93.24,45.19) ; v1(111.14,45.19) 111.02,45.07 111.02,44.91 111.15,44.79 111.58,44.79 111.78,44.98 111.78,46.4 U11.R7
  TOP w0.152: v1(100.8,45.74) 99.68,44.62 98.08,43.02 98.08,41.48 96.38,39.78 R191.2
  IN2 w0.102: v1(111.14,45.19) 110.74,45.6 110.34,45.6 109.73,44.99 104.5,44.99 103.55,45.94 101,45.94 v1(100.8,45.74) 96.87,45.74 96.3,45.17 95.8,45.17 95.7,45.27 95.7,45.82 95.58,45.94 95.41,45.94 95.29,45.82 95.29,45.24 95.19,45.14 94.99,45.14 94.88,45.24 94.88,45.82 94.76,45.94 94.59,45.94 94.48,45.82 94.48,45.24 94.38,45.14 94.17,45.14 94.07,45.24 94.07,45.57 93.95,45.69 93.81,45.69 93.32,45.19 v1(93.24,45.19)
  IN3 w0.102: v1(98.48,73.37) 98.91,72.94 98.91,71.51 100.86,69.55
  IN3 w0.152: v1(100.8,45.74) 100.8,46.07 100.92,46.19 102.63,46.19 102.76,46.32 102.76,46.72 102.63,46.84 101.57,46.84 101.32,47.09 101.32,47.71 101.53,47.92 101.53,49.4 100.85,50.08 100.85,58.54 101,58.69 101.72,58.69 101.88,58.84 101.88,59.15 101.72,59.3 101,59.3 100.85,59.45 100.85,59.76 101,59.91 101.72,59.91 101.88,60.06 101.88,60.37 101.72,60.52 101,60.52 100.85,60.67 100.85,60.98 101,61.13 101.72,61.13 101.88,61.28 101.88,61.59 101.72,61.74 101,61.74 100.85,61.89 100.85,62.2 101,62.35 101.72,62.35 101.88,62.5 101.88,62.81 101.72,62.96 101,62.96 100.85,63.11 100.85,63.28 101.52,63.95 101.52,68.9 100.86,69.55
  BOTTOM w0.089: U21.BH13 99.01,75.2 99.06,75.15 99.06,73.95 v1(98.48,73.37)
  BOTTOM w0.102: U27.R7 109.79,46.5 110.13,45 110.34,44.79 110.74,44.79 v1(111.14,45.19) ; U26.R7 91.88,46.5 92.22,45 92.43,44.79 92.83,44.79 v1(93.24,45.19)
M_B_A12: length 86.7
  TOP w0.102: v1(93.14,46.82) 93.14,47.08 93.24,47.18 93.47,47.18 93.69,47.41 93.69,47.99 94.38,48.68 U10.N7 ; U11.N7 112.29,48.68 111.6,47.99 111.6,47.41 111.38,47.18 111.15,47.18 111.04,47.08 v1(111.04,46.82)
  TOP w0.152: v1(101.83,47.43) 101.83,47.43 101.6,47.43 97.74,43.56 97.74,41.83 R190.2
  IN2 w0.102: v1(111.04,46.82) 110.64,47.22 106.09,47.22 105.6,47.72 102.12,47.72 v1(101.83,47.43) 101.67,47.26 101.35,47.26 101.24,47.37 101.24,47.58 101.12,47.7 100.95,47.7 100.83,47.58 100.83,47.09 100.56,46.82 v1(93.14,46.82)
  IN3 w0.102: v1(98.48,74.02) 99.15,73.34 99.15,71.59 100.86,69.88
  IN3 w0.152: v1(101.83,47.43) 101.83,47.78 102.11,48.06 103.13,48.06 103.26,48.19 103.26,48.56 103.13,48.69 101.99,48.69 101.86,48.81 101.86,49.2 101.99,49.32 103,49.32 103.12,49.45 103.12,49.83 103,49.96 101.44,49.96 101.31,50.09 101.31,50.48 101.44,50.6 102.5,50.6 102.62,50.73 102.62,51.08 102.5,51.21 101.31,51.21 101.18,51.34 101.18,55.53 101.4,55.76 102.11,55.76 102.23,55.88 102.23,56.32 102.11,56.44 101.31,56.44 101.18,56.57 101.18,56.93 101.31,57.05 102.05,57.05 102.21,57.21 102.21,57.51 102.05,57.66 101.31,57.66 101.18,57.79 101.18,58.15 101.31,58.27 102.05,58.27 102.21,58.43 102.21,63.01 101.85,63.37 101.85,63.82 101.98,63.95 102.23,63.95 102.35,64.07 102.35,64.5 102.23,64.63 101.98,64.63 101.85,64.75 101.85,65.21 101.98,65.34 102.2,65.34 102.35,65.49 102.35,65.8 102.2,65.95 102,65.95 101.85,66.1 101.85,66.41 102,66.56 102.2,66.56 102.35,66.71 102.35,67.02 102.2,67.17 102,67.17 101.85,67.32 101.85,67.63 102,67.78 102.2,67.78 102.35,67.93 102.35,68.24 102.2,68.39 102,68.39 101.85,68.54 101.85,68.93 100.89,69.88 100.86,69.88
  BOTTOM w0.089: v1(98.48,74.02) 98.88,74.42 98.88,75.07 98.83,75.12 98.83,75.65 98.71,75.76 98.71,76.01 99.01,76.31 U21.BG13
  BOTTOM w0.102: U27.N7 110.23,47.38 110.39,47.22 110.64,47.22 v1(111.04,46.82) ; v1(93.14,46.82) 92.73,47.22 92.48,47.22 92.32,47.38 U26.N7
M_B_A13: length 82.4
  TOP w0.102: v1(110.51,43.57) 110.51,43.77 110.06,44.22 110.06,44.69 109.92,44.83 109.77,44.83 109.63,44.69 109.43,44.69 109.3,44.82 109.3,45.02 109.4,45.12 109.62,45.12 109.71,45.22 109.71,45.42 109.61,45.53 109.36,45.53 109.26,45.63 U11.T3 ; v1(92.6,43.57) 92.6,43.77 92.15,44.22 92.15,44.69 92.01,44.83 91.87,44.83 91.73,44.69 91.52,44.69 91.39,44.82 91.39,45.02 91.49,45.12 91.71,45.12 91.81,45.22 91.81,45.42 91.7,45.53 91.45,45.53 91.35,45.63 U10.T3
  TOP w0.152: R198.2 103.92,39.89 103.92,42.7 v1(103.29,43.32)
  IN2 w0.102: v1(110.51,43.57) 110.36,43.57 110.32,43.53 110,43.53 109.89,43.43 109.89,43.29 109.79,43.19 109.59,43.19 109.49,43.29 109.49,43.43 109.39,43.53 109.18,43.53 109.08,43.43 109.08,43.29 108.98,43.19 108.78,43.19 108.67,43.29 108.67,43.43 108.57,43.53 108.37,43.53 108.27,43.43 108.27,43.28 108.17,43.18 107.96,43.18 107.86,43.28 107.86,43.43 107.76,43.53 107.56,43.53 107.46,43.43 107.46,43.28 107.35,43.18 107.15,43.18 107.05,43.28 107.05,43.43 106.95,43.53 106.74,43.53 106.64,43.43 106.64,43.28 106.54,43.18 106.34,43.18 106.24,43.28 106.24,43.43 106.13,43.53 105.93,43.53 105.83,43.43 105.83,43.28 105.73,43.18 105.53,43.18 105.42,43.28 105.42,43.43 105.32,43.53 105.12,43.53 105.02,43.43 105.02,43.28 104.92,43.18 104.71,43.18 104.61,43.28 104.61,43.43 104.51,43.53 104.31,43.53 104.2,43.43 104.2,43.28 104.1,43.18 103.9,43.18 103.8,43.28 103.8,43.43 103.7,43.53 103.49,43.53 v1(103.29,43.32) 93.57,43.32 93.4,43.16 93.01,43.16 v1(92.6,43.57)
  IN3 w0.102: 106.77,70.43 106.77,71.89 v1(104.11,74.56)
  IN3 w0.152: v1(103.29,43.32) 103.32,43.29 106.95,43.29 108.26,44.61 108.26,48.63 107.5,49.4 107.5,50.05 106.77,50.78 106.77,70.43
  BOTTOM w0.102: v1(104.11,74.56) 104.11,74.89 103.66,75.35 103.66,75.8 103.83,75.98 U21.BH3 ; v1(110.51,43.57) 110.91,43.16 111.31,43.16 111.52,43.37 U27.T3 ; v1(92.6,43.57) 93.01,43.16 93.4,43.16 93.61,43.37 U26.T3
M_B_A14: length 86.3
  TOP w0.102: v1(93.24,43.57) 93.29,43.57 94.28,44.56 94.28,45.1 94.54,45.36 94.54,45.62 94.28,45.88 94.28,46.17 94.38,46.28 U10.T7 ; v1(111.14,43.57) 111.19,43.57 112.18,44.56 112.18,45.1 112.44,45.36 112.44,45.62 112.18,45.88 112.18,46.17 112.29,46.28 U11.T7
  TOP w0.152: v1(100.92,44.22) 99.1,42.4 99.1,40.55 98.41,39.86 R193.2
  IN2 w0.102: v1(111.14,43.57) 110.74,43.97 110.34,43.97 110.1,43.73 102.97,43.73 102.49,44.22 v1(100.92,44.22) 97.3,44.22 97.12,44.04 97.12,43.72 97.02,43.62 96.82,43.62 96.72,43.72 96.72,43.98 96.62,44.08 96.41,44.08 96.31,43.98 96.31,43.72 96.21,43.62 96.01,43.62 95.9,43.72 95.9,43.98 95.8,44.08 95.6,44.08 95.5,43.98 95.5,43.72 95.4,43.62 95.19,43.62 95.09,43.72 95.09,43.98 94.99,44.08 94.79,44.08 94.68,43.98 94.68,43.72 94.58,43.62 94.38,43.62 94.28,43.72 94.28,43.97 94.18,44.07 93.92,44.07 93.42,43.57 v1(93.24,43.57)
  IN3 w0.102: 99.81,67.11 99.81,68.79 97.55,71.04 97.55,72.25 97.4,72.41 v1(96.87,72.41)
  IN3 w0.152: v1(100.92,44.22) 100.02,45.12 98.68,45.12 98.44,44.87 97.88,44.87 97.75,45 97.75,45.7 97.88,45.83 99.86,45.83 99.99,45.95 99.99,46.31 99.86,46.44 97.88,46.44 97.75,46.56 97.75,47 97.88,47.12 100.34,47.12 100.65,47.43 100.65,48.06 100.48,48.24 100.37,48.24 100.11,48.5 100.11,49.42 99.81,49.72 99.81,67.11
  BOTTOM w0.089: 97.66,75.1 97.89,75.33 97.89,75.66 97.79,75.76 97.79,76.01 98.08,76.3 U21.BG15
  BOTTOM w0.102: v1(96.87,72.41) 97.66,73.2 97.66,75.1 ; U26.T7 91.35,45.9 91.88,44.52 92.43,43.97 92.83,43.97 v1(93.24,43.57) ; U27.T7 109.26,45.9 109.79,44.52 110.34,43.97 110.74,43.97 v1(111.14,43.57)
M_B_A15: length 87.2
  TOP w0.102: v1(110.56,48.44) 110.97,48.04 111.36,48.04 111.6,48.27 U11.M7 ; v1(92.65,48.44) 93.06,48.04 93.46,48.04 93.69,48.27 U10.M7
  IN2 w0.102: v1(110.56,48.44) 110.36,48.65 106.75,48.65 106.4,48.99 100.86,48.99 v1(100.62,48.75) 99.73,48.75 99.33,48.34 99.02,48.34 98.92,48.44 98.66,48.44 98.54,48.32 98.54,47.58 98.44,47.48 98.23,47.48 98.13,47.59 98.13,47.92 98.03,48.03 97.83,48.03 97.72,47.92 97.72,47.57 97.62,47.46 94.03,47.46 93.46,48.04 93.06,48.04 v1(92.65,48.44)
  IN3 w0.102: 100.14,68.99 97.92,71.21 97.92,75.22 97.33,75.81 96.14,75.81 95.65,75.32 95.65,74.27 95.78,74.14 96.05,74.14 96.18,74.26 96.18,75.19 96.36,75.37 97.04,75.37 97.29,75.12 97.29,73.27 97.06,73.04 v1(96.87,73.04)
  IN3 w0.152: 100.14,68.99 100.14,68.43 100.25,68.32 100.72,68.32 100.87,68.17 100.87,67.87 100.72,67.71 100.29,67.71 100.14,67.56 100.14,67.26 100.29,67.1 100.69,67.1 100.84,66.95 100.84,66.65 100.69,66.49 100.29,66.49 100.14,66.34 100.14,66.04 100.29,65.88 100.69,65.88 100.84,65.73 100.84,65.43 100.69,65.28 100.29,65.28 100.14,65.12 100.14,64.82 100.29,64.67 100.69,64.67 100.84,64.51 100.84,64.21 100.69,64.06 100.29,64.06 100.14,63.9 100.14,49.86 100.87,49.12 100.87,48.88 100.74,48.75 v1(100.62,48.75)
  BOTTOM w0.089: U21.BG16 97.48,76.13 97.48,75.78 97.34,75.65 97.34,75.33 97.47,75.2 97.47,75.13
  BOTTOM w0.102: v1(92.65,48.44) 92.47,48.44 91.91,49.01 91.02,49.01 90.9,49.13 90.9,49.38 91,49.48 U26.M7 ; 97.47,75.13 97.47,73.65 v1(96.87,73.04) ; v1(110.56,48.44) 110.38,48.44 109.81,49.01 108.92,49.01 108.8,49.13 108.8,49.38 108.9,49.48 U27.M7
  BOTTOM w0.152: v1(100.62,48.75) 100.4,48.75 99.7,48.05 99.7,45.57 97.4,43.26 R433.2
M_B_BS#0: length 90.8
  TOP w0.102: U10.M2 90.24,49.48 90.16,49.39 90.16,49.1 90.25,49.01 90.6,49.01 90.74,49.15 90.93,49.15 91.02,49.06 91.02,48.32 91.13,48.21 91.53,48.21 91.75,47.99 91.75,47.57 92.5,46.82 v1(92.5,46.82) ; v1(110.41,46.82) 110.41,46.82 109.66,47.57 109.66,47.99 109.44,48.21 109.03,48.21 108.93,48.32 108.93,49.06 108.84,49.15 108.64,49.15 108.5,49.01 108.16,49.01 108.07,49.1 108.07,49.39 108.15,49.48 U11.M2
  IN2 w0.102: v1(92.5,46.82) 92.5,46.54 92.63,46.41 93.33,46.41 93.47,46.55 100.57,46.55 103.09,47.31 v1(105.32,47.31) 105.32,46.26 105.45,46.13 105.6,46.13 105.73,46.26 105.73,46.87 105.88,47.02 106.1,47.02 106.2,46.92 106.2,46.19 106.32,46.08 106.48,46.08 106.6,46.19 106.6,46.92 106.71,47.02 107.48,47.02 107.58,46.92 107.58,46.26 107.7,46.14 107.87,46.14 107.99,46.26 107.99,46.92 108.09,47.02 108.29,47.02 108.39,46.92 108.39,46.2 108.51,46.08 108.68,46.08 108.8,46.2 108.8,46.92 108.9,47.02 109.1,47.02 109.2,46.92 109.2,46.27 109.32,46.15 109.49,46.15 109.61,46.27 109.61,46.89 109.74,47.02 110.28,47.02 110.41,46.89 v1(110.41,46.82)
  IN3 w0.152: v1(102.7,73.89) 102.94,73.65 103.54,73.65 104.83,72.35 104.83,65.27 104.68,65.12 104.52,65.12 104.39,65 104.39,64.64 104.52,64.51 104.68,64.51 104.83,64.36 104.83,64.06 104.68,63.9 104.52,63.9 104.39,63.78 104.39,63.42 104.52,63.29 104.68,63.29 104.83,63.14 104.83,62.84 104.68,62.68 104.52,62.68 104.39,62.56 104.39,62.2 104.52,62.07 104.68,62.07 104.83,61.92 104.83,61.62 104.68,61.46 104.52,61.46 104.39,61.34 104.39,60.98 104.52,60.86 104.68,60.86 104.83,60.7 104.83,60.4 104.68,60.25 104.52,60.25 104.39,60.12 104.39,59.76 104.52,59.64 104.68,59.64 104.83,59.48 104.83,59.18 104.68,59.03 104.52,59.03 104.39,58.9 104.39,58.54 104.52,58.42 104.68,58.42 104.83,58.26 104.83,57.96 104.68,57.81 104.52,57.81 104.39,57.68 104.39,57.32 104.52,57.2 104.68,57.2 104.83,57.05 104.83,56.74 104.68,56.59 104.52,56.59 104.39,56.46 104.39,56.11 104.52,55.98 104.68,55.98 104.83,55.83 104.83,55.46 104.68,55.31 104.52,55.31 104.39,55.18 104.39,54.83 104.52,54.7 104.68,54.7 104.83,54.55 104.83,54.24 104.68,54.09 104.52,54.09 104.39,53.97 104.39,53.61 104.52,53.48 104.68,53.48 104.83,53.33 104.83,53.03 104.68,52.87 104.52,52.87 104.39,52.75 104.39,51.19 104.83,50.74 104.83,49.2 105.51,48.53 105.51,47.5 v1(105.32,47.31)
  BOTTOM w0.089: U21.BH6 102.31,75.75 102.31,75.36 102.62,75.05 102.62,73.97 v1(102.7,73.89)
  BOTTOM w0.102: U26.M2 94.92,48.58 94.6,48.27 94.47,48.27 94.22,48.02 93.8,47.09 93.54,46.83 93.54,46.65 93.31,46.41 92.91,46.41 v1(92.5,46.82) ; U27.M2 112.83,48.58 112.51,48.27 112.38,48.27 112.13,48.02 111.71,47.09 111.45,46.83 111.45,46.65 111.21,46.41 110.82,46.41 v1(110.41,46.82)
  BOTTOM w0.152: v1(105.32,47.31) 105.32,46.36 105.31,46.35 v1(105.31,42.85) 105.31,40.26 R440.2
