# Allegro board Quanta Z8P DA0Z8PMB8D0 REV D - BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_A_A14: length 87.1
  TOP w0.102: v1(75.96,43.57) 76.01,43.57 77,44.56 77,45.1 77.26,45.36 77.26,45.62 77,45.88 77,46.17 77.11,46.28 U9.T7 ; v1(58.06,43.57) 58.11,43.57 59.1,44.56 59.1,45.1 59.36,45.36 59.36,45.62 59.1,45.88 59.1,46.17 59.2,46.28 U8.T7
  TOP w0.152: v1(65.74,44.22) 64.88,43.35 v1(64.88,40.57) 64.25,39.94 R181.2
  IN2 w0.102: v1(58.06,43.57) 58.24,43.57 58.74,44.07 59,44.07 59.1,43.97 59.1,43.72 59.2,43.62 59.4,43.62 59.51,43.72 59.51,43.98 59.61,44.08 59.81,44.08 59.91,43.98 59.91,43.72 60.01,43.62 60.22,43.62 60.32,43.72 60.32,43.98 60.42,44.08 60.62,44.08 60.73,43.98 60.73,43.72 60.83,43.62 61.03,43.62 61.13,43.72 61.13,43.98 61.23,44.08 61.44,44.08 61.54,43.98 61.54,43.72 61.64,43.62 61.84,43.62 61.94,43.72 61.94,44.04 62.12,44.22 v1(65.74,44.22) 67.31,44.22 67.79,43.73 74.92,43.73 75.16,43.97 75.56,43.97 v1(75.96,43.57)
  IN3 w0.152: v1(65.74,44.22) 64.83,45.13 64.83,46.38 64.65,46.56 64.1,46.56 63.89,46.78 63.89,47.1 64.13,47.34 65.38,47.34 65.59,47.55 65.59,49.26 63.84,51.01 63.84,53.73 64.82,54.71 64.82,57.92 64.3,58.45 64.3,64.09 67.6,67.4 68.15,67.4 68.99,68.24 v1(68.99,69.2)
  BOTTOM w0.089: 76.82,74.12 78.06,74.12 78.94,75 78.94,75.18 79.11,75.35 79.11,75.57 79.02,75.77 79.02,76.21 U21.BG56
  BOTTOM w0.102: 76.82,74.12 76.04,74.12 75.69,74.47 73.55,74.47 ; U25.T7 74.08,45.9 74.61,44.52 75.16,43.97 75.56,43.97 v1(75.96,43.57) ; U24.T7 56.17,45.9 56.7,44.52 57.25,43.97 57.65,43.97 v1(58.06,43.57)
  BOTTOM w0.152: 73.55,74.47 72.94,74.47 68.96,70.5 68.96,69.23 v1(68.99,69.2)
M_A_A15: length 89.1
  TOP w0.102: v1(57.47,48.44) 57.88,48.04 58.28,48.04 58.51,48.27 U8.M7 ; U9.M7 76.42,48.27 76.18,48.04 75.79,48.04 v1(75.38,48.44)
  IN2 w0.102: v1(57.47,48.44) 57.88,48.04 58.28,48.04 58.85,47.46 62.44,47.46 62.55,47.57 62.55,47.92 62.65,48.03 62.85,48.03 62.95,47.92 62.95,47.57 63.05,47.47 63.26,47.47 63.36,47.57 63.36,48.32 63.48,48.44 63.65,48.44 63.76,48.32 63.76,48.18 63.88,48.06 64.05,48.06 64.17,48.18 64.17,48.6 64.31,48.75 v1(65.13,48.75) 65.38,48.99 71.22,48.99 71.57,48.65 75.18,48.65 v1(75.38,48.44)
  IN3 w0.152: v1(68.41,68.84) 68.41,68.13 68.01,67.73 67.46,67.73 63.97,64.23 63.97,58.66 63.51,58.2 63.51,57.9 63.67,57.74 64.34,57.74 64.49,57.59 64.49,57.29 64.34,57.13 63.67,57.13 63.51,56.98 63.51,56.68 63.67,56.52 64.34,56.52 64.49,56.37 64.49,56.07 64.34,55.91 63.67,55.91 63.51,55.76 63.51,55.46 63.67,55.3 64.34,55.3 64.49,55.15 64.49,54.85 64.34,54.69 63.67,54.69 63.51,54.54 63.51,50.87 65.13,49.25 v1(65.13,48.75)
  BOTTOM w0.102: 73.37,74.87 75.59,74.87 76.13,74.33 77.06,74.33 77.67,74.94 77.97,74.94 78.33,75.3 78.33,75.53 78.69,75.89 78.69,76.56 U21.BG57 ; U24.M7 55.82,49.48 55.72,49.38 55.72,49.13 55.84,49.01 56.73,49.01 57.29,48.44 v1(57.47,48.44) ; v1(75.38,48.44) 75.2,48.44 74.63,49.01 73.75,49.01 73.63,49.13 73.63,49.38 73.73,49.48 U25.M7
  BOTTOM w0.152: 73.37,74.87 71.67,74.87 71.5,74.7 71.5,74.47 71.89,74.09 71.89,73.91 71.6,73.62 71.42,73.62 71.04,74 70.8,74 70.57,73.77 70.57,73.53 70.85,73.25 70.85,73.07 70.57,72.78 70.39,72.78 70.1,73.07 69.87,73.07 68.12,71.32 68.12,69.12 v1(68.41,68.84) ; R421.2 v1(63.23,40.69) 63.23,44.27 64.66,45.7 64.66,48.27 v1(65.13,48.75)
M_A_BS#0: length 97
  TOP w0.102: U8.M2 55.06,49.48 54.98,49.39 54.98,49.1 55.08,49.01 55.42,49.01 55.56,49.15 55.75,49.15 55.84,49.06 55.84,48.32 55.95,48.21 56.35,48.21 56.57,47.99 56.57,47.57 57.32,46.82 v1(57.32,46.82) ; v1(75.23,46.82) 75.23,46.82 74.48,47.57 74.48,47.99 74.26,48.21 73.85,48.21 73.75,48.32 73.75,49.06 73.66,49.15 73.46,49.15 73.32,49.01 72.98,49.01 72.89,49.1 72.89,49.39 72.97,49.48 U9.M2
  IN2 w0.102: v1(75.23,46.82) 75.23,46.89 75.1,47.02 74.56,47.02 74.43,46.89 74.43,46.27 74.31,46.15 74.14,46.15 74.03,46.27 74.03,46.92 73.92,47.02 73.72,47.02 73.62,46.92 73.62,46.2 73.5,46.08 73.33,46.08 73.21,46.2 73.21,46.92 73.11,47.02 72.91,47.02 72.81,46.92 72.81,46.26 72.69,46.14 72.52,46.14 72.4,46.26 72.4,46.92 72.3,47.02 71.63,47.02 71.53,46.92 71.53,46.19 71.41,46.08 71.24,46.08 71.13,46.19 71.13,46.92 71.02,47.02 70.8,47.02 70.66,46.87 70.66,46.26 70.53,46.13 70.27,46.13 70.13,46.27 v1(70.13,47.24) 67.67,47.24 65.39,46.55 58.29,46.55 58.15,46.41 57.45,46.41 57.32,46.54 v1(57.32,46.82)
  IN3 w0.152: v1(70.13,47.24) 70.04,47.33 70.04,48.35 70.69,49 70.69,60.51 72.86,62.68 73.07,62.68 73.42,62.33 73.64,62.33 73.86,62.54 73.86,62.76 73.5,63.11 73.5,63.33 73.72,63.54 73.94,63.54 74.29,63.19 74.5,63.19 74.72,63.41 74.72,63.62 74.37,63.97 74.37,64.6 74.52,64.75 75.78,64.75 75.91,64.88 75.91,65.23 75.78,65.36 74.52,65.36 74.37,65.51 74.37,70.78 75.07,71.49 79.87,71.49 80.26,71.09 80.89,71.09 81.53,71.73 81.53,72.15 81.88,72.5 81.88,72.94 82.11,73.17 v1(82.11,73.75)
  BOTTOM w0.089: v1(82.11,73.75) 82.11,74.01 82.5,74.4 82.5,75.2 U21.BJ48
  BOTTOM w0.102: v1(75.23,46.82) 75.64,46.41 76.03,46.41 76.27,46.65 76.27,46.83 76.53,47.09 76.95,48.02 77.2,48.27 77.33,48.27 77.65,48.58 U25.M2 ; v1(57.32,46.82) 57.73,46.41 58.13,46.41 58.36,46.65 58.36,46.83 58.63,47.09 59.04,48.02 59.29,48.27 59.42,48.27 59.74,48.58 U24.M2
  BOTTOM w0.152: R428.2 71.08,40.2 v1(71.08,42.92) 71.08,45.41 70.6,45.89 70.6,46.76 v1(70.13,47.24)
M_A_BS#1: length 100.8
  TOP w0.102: U8.N8 59.84,47.97 59.69,46.93 59.42,46.66 59.27,46.66 58.89,46.29 58.89,44.64 58.23,43.97 57.83,43.97 v1(57.42,44.38) ; U9.N8 77.75,47.97 77.6,46.93 77.33,46.66 77.18,46.66 76.8,46.29 76.8,44.64 76.13,43.97 75.74,43.97 v1(75.33,44.38)
  TOP w0.152: R187.2 v1(70.34,40.44) 70.34,42.67 68.79,44.22 v1(67.89,44.22)
  IN2 w0.102: v1(75.33,44.38) 75.11,44.38 74.67,43.93 73.18,43.93 73.07,44.04 73.07,44.28 72.97,44.38 72.77,44.38 72.67,44.28 72.67,44.06 72.57,43.96 72.36,43.96 72.26,44.06 72.26,44.28 72.16,44.38 71.96,44.38 71.85,44.28 71.85,44.06 71.75,43.96 71.55,43.96 71.45,44.06 71.45,44.28 71.35,44.38 71.14,44.38 71.04,44.28 71.04,44.06 70.94,43.96 70.74,43.96 70.64,44.06 70.64,44.28 70.53,44.38 70.33,44.38 70.23,44.28 70.23,44.06 70.13,43.96 69.92,43.96 69.82,44.06 69.82,44.28 69.72,44.38 69.52,44.38 69.42,44.28 69.42,44.06 69.31,43.96 69.11,43.96 69.01,44.06 69.01,44.28 68.91,44.38 68.05,44.38 v1(67.89,44.22) 67.48,44.62 61.67,44.62 61.39,44.34 58.59,44.34 58.23,43.97 57.83,43.97 v1(57.42,44.38)
  IN3 w0.152: v1(67.89,44.22) 67.89,44.76 68.32,45.19 68.32,47.1 70.36,49.14 70.36,61.77 70.58,61.99 70.8,61.99 71.1,61.69 71.28,61.69 71.54,61.94 71.54,62.12 70.95,62.71 70.95,62.89 71.2,63.14 71.38,63.14 72.02,62.49 72.2,62.49 72.45,62.74 72.45,62.92 71.97,63.41 71.97,63.59 72.22,63.84 72.4,63.84 72.86,63.38 73.04,63.38 73.29,63.63 73.29,63.81 72.9,64.2 72.9,64.38 74.04,65.52 74.04,70.87 74.91,71.74 80.23,71.74 v1(80.29,71.68)
  BOTTOM w0.089: U21.BG49 82.32,76.3 82.03,76.02 82.03,75.77 82.14,75.66 82.14,74.55 81.91,74.31 81.72,74.31 80.75,73.33 80.75,72.22 80.29,71.76 v1(80.29,71.68)
  BOTTOM w0.102: v1(75.33,44.38) 75.28,44.38 74.63,45.02 74.63,45.47 74.43,45.68 74.43,46.4 74.21,46.61 74.08,46.61 73.61,47.08 73.61,47.89 73.85,48.14 73.85,48.29 73.72,48.42 73.57,48.42 73.4,48.25 73.07,48.25 72.96,48.36 72.96,48.56 73.08,48.68 U25.N8 ; v1(57.42,44.38) 57.37,44.38 56.73,45.02 56.73,45.47 56.52,45.68 56.52,46.4 56.3,46.61 56.17,46.61 55.7,47.08 55.7,47.89 55.94,48.14 55.94,48.29 55.82,48.42 55.66,48.42 55.5,48.25 55.16,48.25 55.05,48.36 55.05,48.56 55.17,48.68 U24.N8
M_A_BS#2: length 87.2
  TOP w0.102: U9.M3 74.24,49.31 74.24,49.01 74.4,48.85 74.77,48.85 74.85,48.77 74.85,48.19 75,48.04 75.32,48.04 75.38,47.98 v1(75.38,47.63) ; U8.M3 56.34,49.31 56.34,49.01 56.49,48.85 56.86,48.85 56.94,48.77 56.94,48.19 57.1,48.04 57.42,48.04 57.47,47.98 v1(57.47,47.63)
  IN2 w0.102: v1(75.38,47.63) 75.22,47.47 71.14,47.47 70.69,47.92 v1(65.13,47.92) 65.13,47.72 65.43,47.42 65.43,47.15 65.3,47.02 64.85,47.02 64.72,47.15 64.72,47.74 64.6,47.86 64.43,47.86 64.31,47.74 64.31,47.19 64.18,47.06 58.29,47.06 58.13,47.22 57.88,47.22 v1(57.47,47.63)
  IN3 w0.152: v1(65.13,47.92) 64.24,47.92 62.75,46.43 62.57,46.43 62.12,46.89 62.12,47.07 63.52,48.48 64.34,48.48 64.66,48.8 64.66,49.25 63.18,50.74 63.18,58.34 63.64,58.79 63.64,64.37 67.62,68.35 v1(67.89,68.35)
  BOTTOM w0.102: v1(57.47,47.63) 57.88,48.04 58.28,48.04 58.64,48.4 U24.M3 ; U25.M3 76.55,48.4 76.18,48.04 75.79,48.04 v1(75.38,47.63) ; 73.36,75.26 75.49,75.26 76.22,74.53 76.9,74.53 77.51,75.14 77.88,75.14 78.11,75.36 78.11,75.83 U21.BH57
  BOTTOM w0.152: v1(67.89,68.35) 67.65,68.59 67.65,71.4 71.51,75.26 73.36,75.26 ; R422.2 v1(64.25,42.09) 64.25,44.61 65.13,45.5 v1(65.13,47.92)
M_A_CAS#: length 93.1
  TOP w0.102: U8.K3 56.17,51.35 56.39,51.58 56.55,51.58 56.69,51.44 56.69,50.99 56.8,50.88 v1(57.47,50.88) ; U9.K3 74.08,51.35 74.3,51.58 74.46,51.58 74.6,51.44 74.6,50.99 74.71,50.88 v1(75.38,50.88)
  IN2 w0.102: v1(75.38,50.88) 75.05,50.88 74.67,50.51 72.37,50.51 71.67,51.21 70.61,51.21 70.51,51.31 70.51,51.75 70.39,51.87 70.22,51.87 70.11,51.75 70.11,51.29 70.02,51.21 69.78,51.21 69.7,51.29 69.7,51.75 69.58,51.87 69.41,51.87 69.29,51.75 69.29,51.31 69.19,51.21 68.98,51.21 68.89,51.31 68.89,51.75 68.77,51.87 68.6,51.87 68.48,51.75 68.48,51.29 68.4,51.21 68.22,51.21 v1(68.02,51.41) 62.63,51.41 61.72,50.51 58.27,50.51 58.24,50.47 57.88,50.47 v1(57.47,50.88)
  IN3 w0.152: v1(68.02,51.41) 68.37,51.06 68.6,51.06 68.84,51.3 68.84,52.67 68.96,52.8 69.21,52.8 69.37,52.95 69.37,53.26 69.21,53.41 68.96,53.41 68.84,53.54 68.84,53.89 68.96,54.02 69.21,54.02 69.37,54.17 69.37,54.48 69.21,54.63 68.96,54.63 68.84,54.76 68.84,55.11 68.96,55.24 69.21,55.24 69.37,55.39 69.37,55.69 69.21,55.85 68.96,55.85 68.84,55.97 68.84,56.33 68.96,56.46 69.21,56.46 69.37,56.61 69.37,56.91 69.21,57.07 68.96,57.07 68.84,57.19 68.84,57.55 68.96,57.68 69.21,57.68 69.37,57.83 69.37,64.45 72.35,67.43 72.35,70.47 75.79,73.91 77.15,73.91 77.36,73.7 78.39,73.7 78.63,73.93 78.63,74.27 78.75,74.4 79.16,74.4 79.28,74.27 79.28,74.01 79.43,73.86 80.26,73.86 80.57,74.17 81.1,74.17 81.11,74.16 81.3,73.97 81.3,73.79 81.15,73.65 81.12,73.62 81.12,73.05 81.32,72.84 v1(81.32,72.61)
  BOTTOM w0.089: U21.BH47 83.25,75.27 83.24,75.26 83.24,71.89 83.15,71.8 81.89,71.8 81.8,71.71 81.8,71.53 81.89,71.44 83.15,71.44 83.24,71.35 83.24,71.16 83.12,71.03 81.63,71.03 81.5,71.16 81.5,72.43 v1(81.32,72.61)
  BOTTOM w0.102: v1(57.47,50.88) 57.88,50.47 58.22,50.47 U24.K3 ; v1(75.38,50.88) 75.79,50.47 76.13,50.47 U25.K3
  BOTTOM w0.152: v1(68.02,51.41) 68.02,46.25 69.93,44.34 69.93,41.08 v1(69.59,40.73) R426.2
M_A_CKE0: length 90.1
  TOP w0.102: v1(57.47,50.07) 57.88,50.47 58.17,50.47 59.01,50.75 60.31,50.75 U8.K9 ; v1(75.38,50.07) 75.79,50.47 76.08,50.47 76.65,50.66 78.03,50.66 U9.K9
  IN2 w0.102: v1(57.47,50.07) 57.47,49.79 57.6,49.66 58.28,49.66 58.64,49.3 58.74,49.3 58.84,49.4 58.84,49.97 58.94,50.07 59.14,50.07 59.25,49.97 59.25,49.4 59.35,49.3 59.55,49.3 59.65,49.4 59.65,49.97 59.75,50.07 59.96,50.07 60.06,49.97 60.06,49.4 60.16,49.3 60.89,49.3 60.98,49.39 60.98,50 61.08,50.1 61.8,50.1 61.91,49.99 61.91,49.42 62.01,49.32 62.22,49.32 62.32,49.42 62.32,49.7 62.42,49.81 62.74,49.81 62.82,49.89 62.82,50.09 62.7,50.21 62.31,50.21 62.23,50.29 62.23,50.43 62.6,50.8 63.19,50.8 63.28,50.72 v1(63.28,49.82) 64.27,50.8 71.5,50.8 72.5,49.8 72.5,49.7 72.73,49.47 73.07,49.47 73.66,50.07 v1(75.38,50.07)
  IN3 w0.102: 71.48,73.01 74.12,75.64 74.81,75.64 75.07,75.89 75.07,76.27 75.37,76.57 75.96,76.57 76.08,76.7 76.08,76.93 75.85,77.16 75.85,77.5 76.18,77.83 76.37,77.83 76.49,77.71 76.49,77.29 76.72,77.06 v1(76.72,76.62)
  IN3 w0.152: 71.48,73.01 63.08,64.6 63.08,59.03 62.62,58.57 62.62,50.47 v1(63.28,49.82)
  BOTTOM w0.102: U25.K9 72.56,51.08 72.89,50.75 73.27,50.75 73.5,50.52 73.64,50.52 73.86,50.75 74.12,50.75 74.53,50.34 74.87,50.34 75.01,50.48 75.26,50.48 75.38,50.36 v1(75.38,50.07) ; U24.K9 54.65,51.08 54.98,50.75 55.37,50.75 55.59,50.52 55.73,50.52 55.96,50.75 56.21,50.75 56.62,50.34 56.96,50.34 57.1,50.48 57.35,50.48 57.47,50.36 v1(57.47,50.07) ; U21.BH61 76.57,76.47 v1(76.72,76.62)
  BOTTOM w0.152: v1(63.28,49.82) 62.72,49.26 62.72,45.18 61.2,43.66 v1(61.2,40.55) R419.2
M_A_CLK0: length 80
  TOP w0.102: U9.J7 77.01,51.88 76.94,51.81 76.94,51.65 77.08,51.51 77.08,51.34 76.81,51.08 76.68,51.08 76.07,51.69 v1(76.07,51.69) ; v1(57.27,51.72) 57.51,51.97 57.82,52.1 58.06,52.1 58.86,51.85 58.96,51.85 U8.J7
  TOP w0.114: R154.2 66.67,52.98 66.95,52.98 v1(67.19,53.22)
  IN2 w0.102: 71.26,52.16 71.35,52.07 71.68,52.07 72.64,51.12 73.92,51.12 74.9,52.1 75.66,52.1 v1(76.07,51.69) ; v1(57.27,51.72) 57.65,52.1 58.07,52.1 59.06,51.12 61.36,51.12 62.48,52.24 62.48,52.25 62.52,52.29 62.52,52.3 62.54,52.32
  IN2 w0.114: 71.26,52.16 70.06,53.37 69.36,53.37 69.07,53.08 69.07,52.7 68.96,52.59 68.67,52.59 68.55,52.7 68.55,52.99 68.3,53.24 67.21,53.24 v1(67.19,53.22) 67,53.02 63.25,53.02 62.54,52.32
  IN3 w0.114: v1(83.65,77.62) 83.42,77.39 83.08,77.39 82.82,77.13 82.82,76.7 83.09,76.43 83.09,76.25 82.78,75.95 82.6,75.95 82.17,76.38 81.63,76.38 81.37,76.12 81.37,75.53 81.27,75.43 77.26,75.43 77.03,75.66 76.24,75.66 71.26,70.68 71.26,67.88 67.87,64.49 67.87,63.79 67.73,63.64 66.48,63.64 66.18,63.35 66.18,62.8 66.43,62.54 68.17,62.54 68.28,62.43 68.28,62.04 68.17,61.92 66.41,61.92 66.16,61.67 66.16,61.12 66.41,60.87 68.17,60.87 68.28,60.75 68.28,60.36 68.17,60.25 66.41,60.25 66.16,59.99 66.16,59.44 67.31,58.29 67.31,56.4 67.75,55.95 67.75,53.22 67.49,52.95 67.28,52.95 67.19,53.04 v1(67.19,53.22)
  BOTTOM w0.102: U25.J7 74.19,51.77 74.38,51.77 75.17,52.1 75.66,52.1 v1(76.07,51.69) ; U24.J7 56.41,51.88 56.5,51.79 56.5,51.11 56.61,51 56.73,51 57.27,51.54 v1(57.27,51.72)
  BOTTOM w0.14: U21.BD45 84.1,78.08 83.65,77.63 v1(83.65,77.62)
M_A_CLK0#: length 79.9
  TOP w0.102: U9.K7 77.1,51.08 76.89,50.87 76.6,50.87 76.18,51.29 75.9,51.29 75.49,51.69 v1(75.43,51.69) ; U8.K7 59.14,51.08 59.03,51.19 59.03,51.31 59.2,51.48 59.2,51.58 59.14,51.64 58.83,51.64 58.16,51.86 58.07,51.86 v1(57.91,51.69)
  TOP w0.114: v1(67.19,52.44) 66.88,52.76 66.64,52.76 R154.1
  IN2 w0.102: v1(75.43,51.69) 75.43,51.84 75.37,51.9 74.99,51.9 74.87,51.79 74.87,51.42 74.76,51.31 74.39,51.31 74,50.92 72.55,50.92 71.6,51.87 71.26,51.87 71.13,52 71.12,52 71.11,52.01 ; v1(57.91,51.69) 57.78,51.69 57.64,51.56 57.64,51.34 57.7,51.29 58.1,51.29 58.25,51.44 58.45,51.44 58.97,50.92 61.45,50.92 62.69,52.16
  IN2 w0.114: 71.11,52.01 69.97,53.15 69.45,53.15 69.29,52.99 69.29,52.61 69.05,52.37 68.58,52.37 68.34,52.61 68.34,52.9 68.23,53.01 67.63,53.01 67.38,52.76 67.31,52.76 67.19,52.64 v1(67.19,52.44) 66.83,52.81 63.34,52.81 62.69,52.16
  IN3 w0.114: v1(83.65,76.96) 83.44,77.17 83.17,77.17 83.04,77.04 83.04,76.79 83.31,76.52 83.31,76.16 82.87,75.73 82.51,75.73 82.08,76.16 81.72,76.16 81.59,76.03 81.59,75.44 81.36,75.22 77.17,75.22 76.94,75.45 76.33,75.45 71.47,70.59 71.47,67.79 68.09,64.4 68.09,63.7 67.82,63.43 66.57,63.43 66.4,63.26 66.4,62.89 66.52,62.76 68.26,62.76 68.5,62.52 68.5,61.95 68.26,61.71 66.5,61.71 66.37,61.58 66.37,61.21 66.5,61.08 68.26,61.08 68.5,60.84 68.5,60.27 68.26,60.03 66.5,60.03 66.37,59.9 66.37,59.53 67.53,58.38 67.53,56.49 67.97,56.04 67.97,53.13 67.57,52.74 67.32,52.74 67.19,52.61 v1(67.19,52.44)
  BOTTOM w0.102: U25.K7 74.2,50.96 74.33,50.96 74.46,51.09 74.46,51.23 74.36,51.33 74.36,51.51 74.42,51.57 74.69,51.68 75.21,51.9 75.36,51.9 75.43,51.82 v1(75.43,51.69) ; v1(57.91,51.69) 57.91,51.61 57.59,51.29 57.3,51.29 56.82,50.8 56.45,50.8 U24.K7
  BOTTOM w0.14: v1(83.65,76.96) 83.77,76.96 84.1,77.3 U21.BE45
M_A_CS#0: length 96.9
  TOP w0.102: U9.L2 74.21,49.81 74.34,49.69 74.54,49.36 75.05,48.85 75.61,48.85 v1(76.01,48.44) ; U8.L2 56.31,49.81 56.43,49.69 56.64,49.36 57.15,48.85 57.7,48.85 v1(58.11,48.44)
  IN2 w0.102: v1(58.11,48.44) 58.31,48.65 58.93,48.65 59.03,48.54 59.03,47.79 59.15,47.67 59.32,47.67 59.44,47.79 59.44,48.54 59.54,48.65 59.74,48.65 59.84,48.54 59.84,47.79 59.96,47.67 60.13,47.67 60.25,47.79 60.25,48.54 60.35,48.65 60.55,48.65 60.65,48.54 60.65,47.79 60.77,47.67 60.94,47.67 61.06,47.79 61.06,48.54 61.16,48.65 61.37,48.65 61.47,48.54 61.47,48.39 61.57,48.28 61.77,48.28 61.87,48.39 61.87,48.54 61.98,48.65 62.44,48.65 62.55,48.54 62.55,48.35 62.66,48.23 62.83,48.23 62.95,48.35 62.95,48.54 63.06,48.65 63.64,48.65 v1(64.04,49.05) 64.18,49.19 71.31,49.19 71.65,48.85 75.61,48.85 v1(76.01,48.44)
  IN3 w0.102: 71.48,73.49 74.64,76.65 75,76.65 75.28,76.93 75.28,77.27 76.82,78.8 78.52,78.8 79.3,79.59 81.3,79.59 82.05,80.34 83.25,80.34 v1(85.51,82.6)
  IN3 w0.152: v1(64.04,49.05) 63.18,49.05 62.29,49.94 62.29,58.71 62.75,59.16 62.75,64.75 71.48,73.49
  BOTTOM w0.102: U24.L2 60.17,49.99 59.94,49.76 59.73,49.76 59.56,49.93 59.38,49.93 59.25,49.81 58.92,49.81 58.51,49.41 58.51,49.09 58.11,48.68 v1(58.11,48.44) ; U21.AR43 85.27,82.37 v1(85.51,82.6) ; v1(76.01,48.44) 76.01,48.68 76.42,49.09 76.42,49.41 76.82,49.81 77.16,49.81 77.28,49.93 77.47,49.93 77.64,49.76 77.85,49.76 78.08,49.99 U25.L2
  BOTTOM w0.152: R420.2 v1(62.22,41.7) 62.22,44.07 63.07,44.92 63.07,48.08 v1(64.04,49.05)
M_A_DQ0: length 51.2
  IN3 w0.127: v1(66.75,77.23) 66.57,77.23 66.27,77.53 64.93,77.53 50.89,63.49 50.89,55.04 53.54,52.39 54.82,52.39 v1(54.96,52.25)
  BOTTOM w0.089: U21.AY62 74.98,79.85 74.79,79.66
  BOTTOM w0.127: 73.66,79.66 72.51,78.51 72.26,78.51 72.13,78.64 72.13,79.35 72,79.48 71.69,79.48 71.57,79.35 71.57,78.64 71.43,78.51 70.23,78.51 69.71,77.99 69.36,77.99 69.17,77.81 69.17,77.45 68.96,77.24 68.66,77.24 68.52,77.38 68.52,78.2 68.39,78.33 68.09,78.33 67.96,78.2 67.96,77.38 67.82,77.24 67.54,77.24 67.4,77.38 67.4,77.61 67.23,77.78 66.6,77.78 66.47,77.65 66.47,77.39 66.62,77.23 v1(66.75,77.23)
  BOTTOM w0.14: v1(54.96,52.25) 54.96,52.27 U24.H8 ; 73.66,79.66 74.79,79.66
M_A_DQ1: length 51.1
  IN3 w0.102: 53.46,52.91 53.71,52.66 59.35,52.66 v1(59.76,53.07)
  IN3 w0.127: 53.46,52.91 51.21,55.16 51.21,63.38 64.97,77.15 65.8,77.15 v1(66.18,76.77)
  BOTTOM w0.089: 74.82,79.34 75.15,79.67 75.56,79.67 75.67,79.56 75.9,79.56 76.19,79.85 U21.AY61
  BOTTOM w0.127: v1(66.18,76.77) 66.17,76.78 68.94,76.78 70.36,78.19 72.64,78.19 73.79,79.34
  BOTTOM w0.14: U24.G2 60.17,53.48 v1(59.76,53.07) ; 73.79,79.34 74.82,79.34
M_A_DQ2: length 49.8
  IN3 w0.102: 53.82,56.03 53.96,55.88 58.36,55.88 59.35,54.9 59.35,54.28 v1(59.76,53.88)
  IN3 w0.127: 53.82,56.03 53.7,56.14 53.7,58.8 55.25,60.35 55.43,60.35 55.64,60.14 55.82,60.14 56,60.32 56,60.5 55.79,60.71 55.79,60.89 55.97,61.07 56.15,61.07 56.36,60.86 56.54,60.86 56.72,61.04 56.72,61.22 56.51,61.43 56.51,62.2 56.63,62.33 57.21,62.33 57.34,62.45 57.34,62.71 57.21,62.84 56.63,62.84 56.51,62.96 56.51,63.22 56.63,63.34 57.21,63.34 57.34,63.47 57.34,63.72 57.21,63.85 56.63,63.85 56.51,63.98 56.51,64.23 56.63,64.36 57.21,64.36 57.34,64.49 57.34,64.74 57.21,64.87 56.63,64.87 56.51,64.99 56.51,65.32 63.44,72.25 63.64,72.25 64.14,72.75 v1(64.14,73.35)
  BOTTOM w0.102: U21.BE62 75.7,77.53 74.68,77.53
  BOTTOM w0.127: v1(64.14,73.35) 65.74,73.35 65.87,73.23 65.87,73.06 66,72.94 66.25,72.94 66.38,73.06 66.38,73.23 66.5,73.35 67.14,73.35 67.54,72.95 67.96,72.95 71.14,76.14 73.29,76.14 74.68,77.53
  BOTTOM w0.14: v1(59.76,53.88) 60.16,54.28 U24.F2
M_A_DQ3: length 50
  IN3 w0.102: v1(56.58,54.67) 56.58,55 56.52,55.07 53.95,55.07 53.31,55.71 53.31,58.71
  IN3 w0.127: v1(63.49,72.73) 56.2,65.44 56.2,62.18 56.05,62.02 55.85,62.02 55.67,62.02 55.48,61.82 55.48,61.64 55.71,61.42 55.71,61.24 55.53,61.06 55.35,61.06 55.1,61.31 54.92,61.31 54.74,61.13 54.74,60.95 54.99,60.7 54.99,60.52 54.81,60.34 54.42,60.34 54.34,60.26 54.34,59.87 54.21,59.75 53.97,59.75 53.84,59.87 53.84,61.31 53.71,61.43 53.44,61.43 53.31,61.31 53.31,58.71
  BOTTOM w0.102: 75.07,76.67 75.25,76.84 75.79,76.84 U21.BG62 ; U24.F7 56.2,54.28 v1(56.58,54.67)
  BOTTOM w0.127: 73.76,75.82 71.28,75.82 67.53,72.07 67.29,72.07 67.16,72.2 67.16,72.43 67.04,72.56 66.78,72.56 66.66,72.43 66.66,71.97 66.53,71.84 66.28,71.84 66.15,71.97 66.15,72.37 66.02,72.5 65.77,72.5 65.64,72.37 65.64,71.9 65.51,71.77 65.26,71.77 65.13,71.9 65.13,72.64 65.01,72.77 64.75,72.77 64.62,72.64 64.62,71.88 64.5,71.75 64.24,71.75 64.12,71.88 64.12,72.59 63.97,72.73 v1(63.49,72.73)
  BOTTOM w0.14: 75.07,76.67 74.61,76.67 73.76,75.82
M_A_DQ4: length 49.5
  IN3 w0.127: v1(54.96,54.67) 54.8,54.82 53.86,54.82 52.93,55.75 52.93,61.94 52.96,61.96 53.2,62.2 53.38,62.2 54.29,61.29 54.47,61.29 54.65,61.47 54.65,61.65 53.73,62.56 53.73,62.74 53.91,62.92 54.09,62.92 55.03,61.99 55.21,61.99 55.39,62.17 55.39,62.35 55.04,62.7 55.04,62.83 55.17,62.96 55.77,62.96 55.9,63.08 55.9,63.36 55.77,63.48 54.55,63.48 54.42,63.61 54.42,63.88 54.55,64.01 55.77,64.01 55.9,64.13 55.9,64.39 55.77,64.51 55.12,64.51 54.99,64.64 54.99,64.9 55.12,65.02 55.77,65.02 55.9,65.15 55.9,65.8 63.95,73.85 v1(64.56,73.85)
  BOTTOM w0.127: v1(64.56,73.85) 64.72,73.69 66.32,73.69 66.48,73.85 67.34,73.85 67.46,73.73 67.46,73.47 67.59,73.34 67.84,73.34 67.97,73.47 67.97,73.73 68.09,73.85 68.41,73.85 71.04,76.48 73.29,76.48 74.67,77.86 U21.BD63
  BOTTOM w0.14: U24.F8 55.37,54.52 55.23,54.67 v1(54.96,54.67)
M_A_DQ5: length 51.8
  IN3 w0.102: 54.5,52.07 54.73,51.84 56.16,51.84 v1(56.57,52.25)
  IN3 w0.127: 54.5,52.07 53.4,52.07 50.57,54.91 50.57,63.61 64.88,77.91 66.42,77.91 66.57,77.76 67.04,77.76 67.37,78.09 v1(67.37,78.28)
  BOTTOM w0.089: U21.AW62 75.83,80.31 75.55,80.03 74.56,80.03
  BOTTOM w0.102: 74.51,79.98 74.56,80.03
  BOTTOM w0.127: v1(67.37,78.28) 68.37,79.27 68.93,79.27 69.07,79.13 69.07,78.45 69.19,78.32 69.5,78.32 69.62,78.45 69.62,79.13 69.76,79.27 71.04,79.27 71.75,79.98 72.3,79.98 72.44,79.84 72.44,79.56 72.56,79.44 72.87,79.44 72.99,79.56 72.99,79.83 73.14,79.98 74.51,79.98
  BOTTOM w0.14: U24.H7 56.57,52.28 v1(56.57,52.25)
M_A_DQ6: length 52.3
  IN3 w0.102: v1(58.95,52.25) 57.18,52.25 55.94,51.02 54.8,51.02 53.94,51.46 53.27,51.75
  IN3 w0.127: 53.27,51.75 53.26,51.76 50.25,54.77 50.25,63.72 64.93,78.39 66.59,78.39 v1(66.71,78.28)
  BOTTOM w0.127: v1(66.71,78.28) 68.03,79.59 v1(69.4,79.59) 70.91,79.59 71.63,80.31 U21.AW63
  BOTTOM w0.14: v1(58.95,52.25) U24.H3
M_A_DQ7: length 50.5
  IN3 w0.102: v1(58.95,54.65) 57.9,54.65 57.8,54.75 57.8,55.28 57.68,55.41 57.34,55.41 57.22,55.28 57.22,54.41 57.07,54.26 54.77,54.26 54.52,54.5
  IN3 w0.127: v1(64.94,74.38) 64.04,74.38 52.63,62.96 52.63,55.6 53.73,54.5 54.52,54.5
  BOTTOM w0.102: 74.7,78.1 75.08,78.1 75.16,78.19 75.64,78.19 U21.BD62
  BOTTOM w0.127: v1(64.94,74.38) 65,74.32 66.04,74.32 66.33,74.62 66.33,75.36 66.46,75.49 66.72,75.49 66.84,75.36 66.84,74.44 66.97,74.31 67.22,74.31 67.35,74.44 67.35,75.36 67.48,75.49 67.73,75.49 67.86,75.36 67.86,74.59 67.99,74.46 68.39,74.46 68.52,74.59 68.52,75.38 68.63,75.49 69.59,75.49 70.93,76.82 73.26,76.82 74.54,78.1 74.7,78.1
  BOTTOM w0.14: v1(58.95,54.65) U24.E3
M_A_DQ8: length 35.6
  IN3 w0.102: 60.16,59.05 60.16,56.42 60.26,56.32 v1(60.57,56.32)
  IN3 w0.127: 60.16,59.05 60.16,59.43 60.27,59.53 60.42,59.53 60.57,59.38 60.96,59.38 61.08,59.51 61.08,59.8 60.96,59.92 60.78,59.92 60.65,60.05 60.65,60.31 60.78,60.44 61.07,60.44 61.2,60.57 61.2,60.83 61.07,60.95 60.79,60.95 60.66,61.08 60.66,61.33 60.79,61.46 61.04,61.46 61.16,61.59 61.16,64.8 74.44,78.08 75.05,78.08 76.52,79.55 76.91,79.55 77.4,80.04 v1(77.4,80.24)
  BOTTOM w0.14: U24.C2 60.17,56.42 60.27,56.32 v1(60.57,56.32) ; v1(77.4,80.24) 77.61,80.45 77.61,80.58 77.49,80.7 U21.AV59
M_A_DQ9: length 35.5
  IN3 w0.102: 54.55,58.87 54.55,57.49 v1(54.96,57.08)
  IN3 w0.114: v1(73.29,81.28) 73.29,81.01
  IN3 w0.127: 73.29,81.01 71.11,78.83 70.97,78.83 57.87,65.73 57.87,61.43 55.95,59.51 55.19,59.51 54.55,58.87
  BOTTOM w0.127: v1(73.29,81.28) 73.5,81.07 74.34,81.07 74.54,81.26 75.36,81.26 U21.AU63
  BOTTOM w0.14: U24.C8 55.36,56.68 v1(54.96,57.08)
M_A_DQ10: length 36.5
  IN3 w0.102: v1(73.93,81.54) 73.76,81.37 73.76,80.93 71.48,78.66 ; 55.51,59.11 55.36,58.97 55.36,56.68 v1(55.76,56.29)
  IN3 w0.127: 71.48,78.66 71.2,78.38 70.95,78.38 58.17,65.6 58.17,61.31 56.07,59.2 55.6,59.2 55.51,59.11
  BOTTOM w0.102: 74.36,81.52 75.56,81.52 75.84,81.24 U21.AU62
  BOTTOM w0.127: v1(73.93,81.54) 73.95,81.52 74.36,81.52
  BOTTOM w0.14: v1(55.76,56.29) U24.D7
M_A_DQ11: length 35.3
  IN3 w0.127: v1(60.57,58.78) 60.98,58.78 61.5,59.3 61.5,60.58 61.63,60.71 61.77,60.71 61.9,60.84 61.9,61.09 61.77,61.22 61.63,61.22 61.5,61.35 61.5,61.6 61.63,61.73 61.77,61.73 61.9,61.85 61.9,62.11 61.77,62.23 61.63,62.23 61.5,62.36 61.5,62.62 61.63,62.74 61.77,62.74 61.9,62.87 61.9,63.12 61.77,63.25 61.63,63.25 61.5,63.38 61.5,63.63 61.63,63.76 61.77,63.76 61.9,63.89 61.9,64.14 61.77,64.27 61.63,64.27 61.5,64.39 61.5,64.71 74.58,77.79 75.11,77.79 76.6,79.27 77.28,79.27 77.43,79.43 77.43,79.7 77.55,79.82 77.76,79.82 77.89,79.69 77.89,79.43 78,79.32 78.36,79.32 78.66,79.61 78.66,79.88 78.31,80.23 v1(78.09,80.23)
  BOTTOM w0.14: v1(78.09,80.23) 78.31,80.45 78.31,80.63 78.23,80.7 U21.AV58 ; U24.A2 60.42,58.28 60.57,58.42 v1(60.57,58.78)
M_A_DQ12: length 34.4
  IN3 w0.102: v1(59.76,57.08) 59.35,57.49 59.35,59.16
  IN3 w0.127: v1(78.22,81.19) 78.18,81.15 77.73,80.7 77.09,80.7 77.04,80.75 76.08,80.75 74.52,79.19 74.49,79.19 60.05,64.75 60.05,60.53 59.35,59.82 59.35,59.16
  BOTTOM w0.14: U21.AV57 78.61,80.7 78.22,81.1 v1(78.22,81.19) ; v1(59.76,57.08) 59.37,56.69 U24.C3
M_A_DQ13: length 37.2
  IN3 w0.102: 57.09,59.16 57.09,58.61 56.58,58.1 v1(56.58,57.88) ; v1(78.92,81.15) 78.91,81.15 78.24,81.83 75.92,81.83 75.34,81.25 74.77,81.25 74.46,80.94 74.46,80.46 71.76,77.76
  IN3 w0.127: 71.76,77.76 71.73,77.74 71.18,77.74 58.78,65.35 58.78,61.05 57.09,59.36 57.09,59.16
  BOTTOM w0.127: U21.AT55 79.33,81.57 v1(78.92,81.15)
  BOTTOM w0.14: v1(56.58,57.88) 56.57,57.88 U24.A7
M_A_DQ14: length 39
  IN3 w0.102: v1(55.77,57.88) 56.18,58.29 56.18,58.88 ; v1(80.32,81.17) 79.93,81.56 78.96,81.56 78.45,82.07 76.58,82.07
  IN3 w0.114: 74.69,81.52 75.95,82.07 76.58,82.07
  IN3 w0.127: 74.69,81.52 74.05,80.88 74.05,80.66 71.45,78.07 71.08,78.07 58.48,65.47 58.48,61.18 56.18,58.88
  BOTTOM w0.127: U21.AT54 80.32,81.38 v1(80.32,81.17)
  BOTTOM w0.14: v1(55.77,57.88) U24.B8
M_A_DQ15: length 35.1
  IN3 w0.127: v1(76.74,80.32) 76.96,80.1 76.96,79.94 76.84,79.82 76.48,79.82 76.09,80.2 75.88,80.2 75.59,79.91 75.59,79.75 75.86,79.49 75.86,79.32 75.7,79.16 75.54,79.16 75.27,79.43 75.11,79.43 74.95,79.27 74.95,79.11 75.21,78.84 75.21,78.68 75.05,78.52 74.25,78.52 60.36,64.62 60.36,64.43 60.49,64.3 60.7,64.3 60.83,64.17 60.83,63.92 60.7,63.79 60.49,63.79 60.36,63.66 60.36,63.41 60.49,63.28 60.73,63.28 60.86,63.16 60.86,62.9 60.73,62.77 60.49,62.77 60.36,62.65 60.36,62.39 60.49,62.27 60.73,62.27 60.86,62.14 60.86,61.89 60.73,61.76 60.49,61.76 60.36,61.63 60.36,60.4 59.76,59.8 v1(59.76,58.68)
  BOTTOM w0.14: v1(76.74,80.32) 76.74,80.21 U21.AY59 ; v1(59.76,58.68) 59.76,58.42 59.61,58.28 U24.A3
M_A_DQ16: length 53.6
  TOP w0.14: U8.H7 59.76,52.29 v1(59.76,52.25)
  IN1 w0.102: v1(78.87,80.26) 78.43,79.82 71.28,79.82 70.4,78.95 70.4,78.94 51.42,59.96 51.42,53.67 52.01,53.08 52.08,53.01 53.15,51.89 53.99,51.52 54.75,51.03 55.97,51.03 57.32,52.38 58.24,52.38 58.78,51.85 59.35,51.85 v1(59.76,52.25)
  BOTTOM w0.152: v1(78.87,80.26) 78.62,80.01 U21.AY57
M_A_DQ17: length 54.7
  TOP w0.14: U8.F8 60.22,54.28 v1(60.57,54.63)
  IN1 w0.102: v1(78.28,78.38) 78.66,78 78.66,77.32 77.35,76.01 75.16,76.01 74.81,75.65 73.81,75.65 67.01,68.86 66.87,68.86 66.46,69.27 66.3,69.27 66.13,69.11 66.13,68.95 66.55,68.53 66.55,68.37 66.38,68.21 66.22,68.21 65.81,68.62 65.65,68.62 65.49,68.46 65.49,68.3 65.9,67.89 65.9,67.72 65.74,67.56 65.58,67.56 65.16,67.98 65,67.98 64.84,67.81 64.84,67.65 65.25,67.24 65.25,67.08 65.09,66.92 64.93,66.92 64.52,67.33 64.35,67.33 64.19,67.17 64.19,67.01 64.61,66.59 64.61,66.43 64.44,66.27 64.28,66.27 63.87,66.68 63.71,66.68 63.55,66.52 63.55,66.36 63.96,65.95 63.96,65.78 63.8,65.62 63.64,65.62 63.22,66.04 63.06,66.04 62.9,65.87 62.9,65.71 63.31,65.3 63.31,65.14 63.15,64.98 62.99,64.98 62.58,65.39 62.41,65.39 62.25,65.23 62.25,65.07 62.67,64.65 62.67,64.49 62.5,64.33 62.34,64.33 61.93,64.74 61.77,64.74 59.47,62.44 58.91,62.44 56.51,60.04 55.73,60.04 54.55,58.86 54.55,56.07 54.74,55.88 57.72,55.88 57.82,55.78 57.82,55.43 57.94,55.31 58.11,55.31 58.23,55.43 58.23,55.78 58.33,55.88 59.95,55.88 60.16,55.67 60.16,54.82 60.35,54.63 v1(60.57,54.63)
  BOTTOM w0.14: U21.BB57 78.62,78.73 v1(78.28,78.38)
M_A_DQ18: length 54.5
  TOP w0.14: U8.F7 59.38,54.28 v1(59.76,54.65)
  IN1 w0.102: v1(59.76,54.65) 59.35,55.06 58.7,55.06 57.71,54.07 57.57,54.07 57.46,54.17 57.46,55.39 57.34,55.51 57.18,55.51 57.06,55.39 57.06,54.17 56.96,54.07 53.84,54.07 53.03,54.88 53.03,58.96 53.74,59.66 54.11,59.66 60.7,66.26 60.88,66.26 61.37,65.77 61.55,65.77 61.7,65.91 61.7,66.09 61.21,66.58 61.21,66.76 61.35,66.9 61.53,66.9 62.02,66.41 62.2,66.41 62.34,66.56 62.34,66.74 61.85,67.23 61.85,67.41 62,67.55 62.18,67.55 62.67,67.06 62.85,67.06 62.99,67.2 62.99,67.38 62.5,67.87 62.5,68.05 62.64,68.2 62.82,68.2 63.32,67.7 63.48,67.7 63.65,67.86 63.65,68.02 63.35,68.32 63.35,68.5 63.49,68.64 63.67,68.64 63.97,68.35 64.13,68.35 73.7,77.92 77.54,77.92 77.61,77.85 v1(77.61,77.49)
  BOTTOM w0.14: v1(77.61,77.49) 77.24,77.86 U21.BD59
M_A_DQ19: length 54
  TOP w0.14: U8.E3 56.57,55.48 v1(56.58,55.48)
  IN1 w0.102: v1(77.35,76.6) 77.35,76.35 77.22,76.21 76.44,76.21 76.31,76.34 76.31,77.14 76.19,77.26 76.03,77.26 75.91,77.14 75.91,76.34 75.78,76.21 75.19,76.21 74.76,76.64 74.4,76.64 72.93,75.17 72.77,75.17 72.31,75.63 72.13,75.63 71.99,75.49 71.99,75.31 72.45,74.85 72.45,74.69 72.29,74.52 72.12,74.52 71.67,74.98 71.49,74.98 71.34,74.84 71.34,74.66 71.8,74.2 71.8,74.04 71.64,73.88 71.48,73.88 71.02,74.34 70.84,74.34 70.7,74.19 70.7,74.01 71.15,73.55 71.15,73.39 70.99,73.23 70.83,73.23 70.43,73.64 70.25,73.64 70.1,73.49 70.1,73.31 70.51,72.91 70.51,72.75 70.35,72.58 70.18,72.58 69.78,72.99 69.6,72.99 69.46,72.84 69.46,72.67 69.86,72.26 69.86,72.1 69.7,71.94 69.54,71.94 69.13,72.34 68.95,72.34 68.81,72.2 68.81,72.02 69.21,71.61 69.21,71.45 69.05,71.29 68.89,71.29 68.49,71.7 68.31,71.7 68.16,71.55 68.16,71.37 68.57,70.97 68.57,70.81 68.41,70.64 68.24,70.64 67.84,71.05 67.66,71.05 67.52,70.9 67.52,70.73 67.92,70.32 67.92,70.16 67.76,70 67.6,70 67.19,70.4 67.01,70.4 66.87,70.26 66.87,70.08 67.27,69.67 67.27,69.51 67.11,69.35 66.95,69.35 66.55,69.76 66.37,69.76 59.34,62.73 58.79,62.73 56.39,60.33 55.6,60.33 54.39,59.12 53.97,59.12 53.72,58.86 53.72,55.33 53.98,55.07 56.18,55.07 v1(56.58,55.48)
  BOTTOM w0.14: v1(77.35,76.6) 77.35,77 U21.BF59
M_A_DQ20: length 58.3
  TOP w0.14: v1(60.57,52.25) 60.57,52.28 U8.H8
  IN1 w0.102: v1(60.57,52.25) 60.33,52.25 59.93,52.66 53.25,52.66 52,53.91 52,59.73 66.79,74.52 66.95,74.52 67.45,74.02 67.61,74.02 67.77,74.18 67.77,74.34 67.28,74.84 67.28,75 67.48,75.21 67.64,75.21 68.14,74.71 68.3,74.71 68.47,74.87 68.47,75.04 67.97,75.53 67.97,75.7 68.13,75.86 68.29,75.86 68.79,75.36 68.95,75.36 72.22,78.63 72.22,78.79 71.98,79.03 71.98,79.21 72.12,79.35 72.3,79.35 72.54,79.11 72.7,79.11 72.93,79.34 78.7,79.34 78.94,79.57 79.72,79.57 79.88,79.73 80.58,79.73 80.69,79.83 80.69,80.01 v1(80.38,80.32)
  BOTTOM w0.14: U21.AV54 80.05,80.65 v1(80.38,80.32)
M_A_DQ21: length 57.3
  TOP w0.14: U8.H3 55.77,52.28 v1(55.77,52.25)
  IN1 w0.102: v1(55.77,52.25) 55.77,51.97 55.65,51.85 54.79,51.85 54.38,52.26 53.24,52.26 51.71,53.79 51.71,59.85 68.21,76.35 68.37,76.35 68.87,75.85 69.03,75.85 69.19,76.02 69.19,76.18 68.7,76.68 68.7,76.84 68.86,77 69.02,77 69.52,76.5 69.68,76.5 69.84,76.66 69.84,76.82 69.34,77.32 69.34,77.48 69.5,77.65 69.67,77.65 70.16,77.15 70.33,77.15 70.49,77.31 70.49,77.47 69.99,77.97 69.99,78.13 70.15,78.29 70.31,78.29 70.81,77.79 70.97,77.79 71.13,77.96 71.13,78.12 70.64,78.62 70.64,78.78 70.8,78.94 70.96,78.94 71.46,78.44 71.62,78.44 71.78,78.6 71.78,78.76 71.28,79.26 71.28,79.42 71.44,79.58 78.65,79.58 78.85,79.78 79.55,79.78 79.69,79.92 v1(79.69,80.34)
  BOTTOM w0.14: U21.AY55 79.33,79.98 79.69,80.34 v1(79.69,80.34)
M_A_DQ22: length 57.8
  TOP w0.14: v1(55.77,53.07) 55.77,53.08 U8.G2
  IN1 w0.102: v1(55.77,53.07) 55.34,53.5 52.87,53.5 52.29,54.07 52.29,59.61 62.83,70.14 62.99,70.14 63.25,69.88 63.43,69.88 63.57,70.03 63.57,70.21 63.31,70.47 63.31,70.65 63.46,70.79 63.64,70.79 64.14,70.29 64.3,70.29 64.46,70.45 64.46,70.62 63.96,71.11 63.96,71.29 64.1,71.44 64.28,71.44 64.78,70.94 64.94,70.94 65.11,71.1 65.11,71.26 64.61,71.76 64.61,71.92 64.77,72.08 64.93,72.08 65.43,71.59 65.59,71.59 65.75,71.75 65.75,71.91 65.25,72.41 65.25,72.57 65.42,72.73 65.58,72.73 66.08,72.23 66.24,72.23 66.4,72.39 66.4,72.56 65.9,73.05 65.9,73.22 66.06,73.38 66.22,73.38 66.72,72.88 66.88,72.88 67.05,73.04 67.05,73.2 66.55,73.7 66.55,73.86 66.71,74.02 66.87,74.02 67.37,73.53 67.53,73.53 73.03,79.02 78.68,79.02 79.02,79.37 79.8,79.37 79.96,79.53 80.95,79.53 81.31,79.89 81.31,80.08 v1(81.08,80.31)
  BOTTOM w0.14: v1(81.08,80.31) 80.76,80.63 U21.AV52
M_A_DQ23: length 55.1
  TOP w0.14: v1(55.77,54.67) 55.76,54.67 U8.F2
  IN1 w0.102: v1(55.77,54.67) 55.77,54.36 55.67,54.26 54.02,54.26 53.37,54.92 53.37,58.88 53.86,59.37 54.23,59.37 56.06,61.2 56.22,61.2 56.44,60.98 56.61,60.98 56.77,61.14 56.77,61.3 56.54,61.52 56.54,61.68 56.71,61.85 56.87,61.85 57.09,61.62 57.25,61.62 57.41,61.78 57.41,61.95 57.19,62.17 57.19,62.33 57.35,62.49 57.51,62.49 57.74,62.27 57.9,62.27 58.06,62.43 58.06,62.59 57.84,62.82 57.84,62.98 58,63.14 58.16,63.14 58.38,62.92 58.55,62.92 58.71,63.08 58.71,63.24 58.48,63.46 58.48,63.62 58.65,63.79 58.81,63.79 59.31,63.29 59.49,63.29 59.63,63.43 59.63,63.61 59.13,64.11 59.13,64.27 59.34,64.48 59.5,64.48 60.01,63.97 60.17,63.97 60.33,64.13 60.33,64.29 59.82,64.8 59.82,64.96 59.98,65.13 60.15,65.13 60.65,64.62 60.82,64.62 60.98,64.78 60.98,64.94 60.47,65.45 60.47,65.61 60.63,65.77 60.79,65.77 61.3,65.26 61.46,65.26 72.22,76.03 72.39,76.03 72.8,75.61 72.96,75.61 73.12,75.77 73.12,75.94 72.71,76.35 72.71,76.51 72.87,76.67 73.03,76.67 73.44,76.26 73.61,76.26 73.77,76.42 73.77,76.58 73.36,77 73.36,77.16 73.71,77.51 73.83,77.51 73.94,77.4 73.94,77.06 74.07,76.93 74.27,76.93 74.4,77.06 74.4,77.4 74.51,77.51 75.16,77.51 75.26,77.41 75.26,76.64 75.38,76.52 75.53,76.52 75.65,76.65 75.65,77.41 75.75,77.51 76.34,77.51 76.77,77.09 78.04,77.09 78.24,77.28 v1(78.24,77.5)
  BOTTOM w0.14: U21.BD58 77.91,77.83 v1(78.24,77.5)
M_A_DQ24: length 38.3
  TOP w0.14: U8.C2 55.35,56.68 v1(54.96,56.29)
  IN1 w0.102: v1(54.96,56.29) 55.36,56.7 55.36,58.87 56.12,59.63 56.84,59.63 59.13,61.92 60.83,61.92 61.29,62.38 61.29,62.54 60.88,62.95 60.88,63.12 61.04,63.28 61.2,63.28 61.61,62.86 61.78,62.86 61.94,63.03 61.94,63.19 61.52,63.6 61.52,63.76 61.69,63.92 61.85,63.92 62.26,63.51 62.42,63.51 67.1,68.19 67.1,68.23 74.11,75.24 74.85,75.24 75.3,75.68 77.36,75.68 78.87,77.19 78.87,77.3 v1(79.24,77.67)
  BOTTOM w0.14: v1(79.24,77.67) 79.09,77.67 U21.BE56
M_A_DQ25: length 37.2
  TOP w0.14: U8.A3 56.57,58.68 v1(56.58,58.68)
  IN1 w0.102: v1(56.58,58.68) 56.58,58.41 56.69,58.31 56.96,58.31 57.07,58.41 57.25,58.41 57.38,58.54 57.38,58.93 59.49,61.04 61.18,61.04 62.77,62.64 62.98,62.64 63.29,62.32 63.47,62.32 63.99,62.84 63.99,63.02 63.66,63.35 63.66,63.52 63.78,63.64 63.95,63.64 64.3,63.29 64.44,63.29 64.58,63.44 64.58,63.58 64.36,63.8 64.36,63.97 64.48,64.09 64.65,64.09 64.87,63.87 65.01,63.87 71.63,70.48 71.63,71.56 74.3,74.24 77.04,74.24 79.04,76.25 79.92,76.25 80.53,76.85 80.53,77.37 v1(80.14,77.75)
  BOTTOM w0.14: v1(80.14,77.75) 80.11,77.75 U21.BD54
M_A_DQ26: length 37.5
  TOP w0.14: v1(55.77,58.68) U8.A2
  IN1 w0.102: v1(79.24,77.04) 77.68,75.48 75.49,75.48 74.99,74.98 74.25,74.98 71.07,71.8 71.07,70.71 68.24,67.88 67.71,67.88 67.54,68.05 67.38,68.05 67.22,67.89 67.22,67.73 67.39,67.56 67.39,67.4 67.23,67.23 67.07,67.23 66.89,67.41 66.73,67.41 66.57,67.24 66.57,67.08 66.74,66.91 66.74,66.75 66.58,66.59 66.42,66.59 66.25,66.76 66.08,66.76 65.92,66.6 65.92,66.44 66.1,66.26 66.1,66.1 65.93,65.94 65.77,65.94 65.6,66.11 65.44,66.11 65.28,65.95 65.28,65.79 65.45,65.62 65.45,65.46 65.29,65.29 65.13,65.29 64.95,65.47 64.79,65.47 64.63,65.3 64.63,65.14 64.8,64.97 64.8,64.81 64.64,64.65 64.48,64.65 64.31,64.82 64.14,64.82 60.95,61.63 59.25,61.63 57,59.38 56.28,59.38 55.77,58.86 v1(55.77,58.68)
  BOTTOM w0.14: U21.BF58 78.22,77.04 v1(79.24,77.04)
M_A_DQ27: length 35.9
  TOP w0.14: v1(58.95,58.68) 59.35,58.28 U8.A7
  IN1 w0.102: v1(58.95,58.68) 58.95,58.94 59.8,59.8 61.74,59.8 61.94,60 62.13,60 62.35,59.79 62.61,59.79 62.74,59.91 62.74,60.01 62.38,60.36 62.38,60.53 62.5,60.64 62.67,60.64 63.02,60.29 63.17,60.29 63.31,60.44 63.31,60.58 63.09,60.8 63.09,60.97 63.21,61.09 63.38,61.09 63.55,60.92 63.79,60.92 72.84,69.97 72.84,71.26 74.73,73.15 77.86,73.15 79.29,74.57 79.29,74.98 79.51,75.2 80.51,75.2 81.14,75.83 81.14,77.85 v1(81.19,77.9)
  BOTTOM w0.102: U21.BE50 81.67,77.42 v1(81.19,77.9)
M_A_DQ28: length 36.8
  TOP w0.14: U8.D7 59.37,55.9 59.76,56.29 v1(59.76,56.3)
  IN1 w0.102: v1(59.76,56.3) 59.35,56.71 59.35,58.86 60,59.51 62.77,59.51 73.14,69.87 73.14,71.13 74.75,72.74 77.92,72.74 79.36,74.18 79.84,74.18 81.34,75.68 81.34,77.47 81.59,77.72 81.59,78.16 v1(81.22,78.54)
  BOTTOM w0.102: v1(81.22,78.54) 81.29,78.54 81.67,78.16 U21.BD50
M_A_DQ29: length 36.8
  TOP w0.14: v1(60.57,57.88) U8.B8
  IN1 w0.102: v1(81.21,79.17) 81.62,78.76 81.62,78.46 81.8,78.29 81.8,77.55 81.68,77.44 81.68,75.56 81.04,74.92 81.04,74.5 79.69,73.15 78.77,73.15 77.96,72.34 74.65,72.34 73.42,71.11 73.42,69.75 67.04,63.38 67.04,63.24 67.17,63.11 67.17,62.94 67.05,62.82 66.88,62.82 66.75,62.95 66.61,62.95 66.42,62.76 66.42,62.62 66.55,62.49 66.55,62.32 66.43,62.21 66.26,62.21 66.14,62.33 65.99,62.33 62.88,59.21 60.43,59.21 60.16,58.95 60.16,58.29 v1(60.57,57.88)
  BOTTOM w0.102: U21.BB50 81.66,78.81 81.3,79.17 v1(81.21,79.17)
M_A_DQ30: length 37.2
  TOP w0.14: v1(60.57,57.03) 60.22,56.68 U8.C8
  IN1 w0.102: v1(60.57,57.03) 60.57,57.3 60.98,57.71 60.98,58.79 61.11,58.92 63.62,58.92 67.77,63.07 67.77,63.22 67.63,63.36 67.63,63.53 67.75,63.64 67.92,63.64 68.06,63.5 68.2,63.5 68.32,63.62 68.32,64.26 73.7,69.64 73.7,70.91 74.84,72.05 78.26,72.05 78.96,72.75 79.9,72.75 81.34,74.18 81.34,74.93 82.6,76.19 82.6,78.62 v1(82.11,79.11)
  BOTTOM w0.14: U21.BA50 81.7,79.52 v1(82.11,79.11)
M_A_DQ31: length 38.2
  TOP w0.14: U8.C3 56.57,56.28 v1(56.57,56.29)
  IN1 w0.102: v1(56.57,56.29) 56.18,56.68 56.18,58.86 56.41,59.09 57.13,59.09 59.37,61.33 61.07,61.33 62.77,63.03 62.93,63.03 63.06,62.91 63.24,62.91 63.38,63.05 63.38,63.23 63.26,63.35 63.26,63.52 64.11,64.37 65.12,64.37 71.35,70.59 71.35,71.68 74.21,74.54 77.05,74.54 79.14,76.63 79.41,76.63 79.65,76.87 79.65,77.87 79.68,77.89 79.68,78.56 v1(79.28,78.96)
  BOTTOM w0.14: v1(79.28,78.96) 79.43,78.81 U21.BB54
M_A_DQ32: length 40.4
  TOP w0.14: U9.F8 78.1,54.28 v1(78.48,54.65)
  IN3 w0.102: v1(78.48,54.65) 78.48,54.39 78.62,54.25 79.46,54.25 79.7,54.48 79.7,54.87 ; 86.38,70.18 86.38,75.75 85.54,76.59 85.54,78.54 85.23,78.85 85.23,80.07 85,80.3 85,80.65 85.13,80.79 85.58,80.79 85.91,81.12 85.91,81.8 86.15,82.04 v1(86.37,82.04)
  IN3 w0.127: 86.38,70.18 86.51,70.05 86.51,67.34 85.79,66.62 85.79,65.25 81.39,60.84 81.39,60.59 81.51,60.47 82.1,60.47 82.23,60.34 82.23,60.09 82.1,59.96 81.39,59.96 81.26,59.83 81.26,59.58 81.39,59.45 82.1,59.45 82.23,59.32 82.23,59.07 82.1,58.94 81.39,58.94 81.26,58.82 81.26,58.56 81.39,58.44 82.08,58.44 82.2,58.31 82.2,58.05 82.08,57.93 81.39,57.93 81.26,57.8 81.26,57.55 81.39,57.42 81.72,57.42 81.84,57.29 81.84,57.04 81.72,56.91 81.39,56.91 81.26,56.78 81.26,56.61 80.55,55.9 80.55,55.72 79.7,54.87
  BOTTOM w0.14: v1(86.37,82.04) 86.62,82.04 86.93,82.35 U21.AR39
M_A_DQ33: length 39
  TOP w0.14: v1(78.48,52.25) 78.48,52.28 U9.H8
  IN3 w0.102: v1(87.39,80.45) 87.39,79.86 86.99,79.46 86.99,78.55 86.83,78.39 86.83,76.91 87.25,76.49 87.44,76.49 88.87,75.05 88.87,69.28 88.69,69.1
  IN3 w0.127: 88.69,69.1 88.4,68.81 88.4,65.08 84.17,60.85 84.17,56.47 84.38,56.27 84.38,56.09 84.2,55.91 84.02,55.91 83.81,56.12 83.63,56.12 83.45,55.94 83.45,55.76 83.68,55.52 83.68,55.34 83.5,55.17 83.32,55.17 83.09,55.4 82.91,55.4 82.73,55.22 82.73,55.04 82.94,54.83 82.94,54.65 82.76,54.47 82.58,54.47 82.37,54.68 82.2,54.68 82.02,54.5 82.02,54.32 82.22,54.11 82.22,53.93 82.04,53.75 81.86,53.75 81.66,53.96 81.48,53.96 79.77,52.25 v1(78.48,52.25)
  BOTTOM w0.14: U21.AV37 87.85,80.91 v1(87.39,80.45)
M_A_DQ34: length 40.6
  TOP w0.14: U9.H7 77.67,52.29 v1(77.67,52.25)
  IN3 w0.102: 80.66,51.85 78.07,51.85 v1(77.67,52.25) ; 89.09,69.6 89.09,75.14 88.92,75.31 88.92,75.47 89.07,75.62 89.07,75.8 88.92,75.94 88.74,75.94 88.59,75.79 88.43,75.79 88.27,75.96 88.27,76.12 88.53,76.38 88.53,76.55 88.38,76.7 88.21,76.7 87.95,76.44 87.79,76.44 87.63,76.6 87.63,76.79 87.87,77.03 87.87,79.16 87.74,79.29 v1(87.4,79.29)
  IN3 w0.127: 80.66,51.85 80.88,51.85 80.96,51.93 80.96,52.11 80.69,52.38 80.69,52.56 80.87,52.74 81.05,52.74 81.32,52.47 81.5,52.47 81.68,52.65 81.68,52.83 81.41,53.1 81.41,53.28 81.59,53.46 81.77,53.46 82.04,53.19 82.22,53.19 84.88,55.85 84.88,61.13 88.7,64.95 88.7,68.61 89.09,69 89.09,69.6
  BOTTOM w0.14: U21.AW37 87.4,79.79 87.4,79.29 v1(87.4,79.29)
M_A_DQ35: length 41.4
  TOP w0.14: v1(76.85,54.65) 76.9,54.65 U9.F7
  IN3 w0.102: v1(76.85,54.65) 76.85,54.27 77.07,54.04 79.59,54.04 80.09,54.55 80.09,54.85 ; v1(87.39,81.87) 87.59,81.87 87.72,82 87.72,82.54 87.59,82.67 87.01,82.67 86.88,82.54 86.88,81.18 86.67,80.98 86.17,80.98 85.49,80.29 85.49,78.88 85.81,78.55 85.81,76.65 87.29,75.18 87.29,70.17 86.81,69.7
  IN3 w0.127: 80.09,54.85 82.6,57.36 82.6,60.4 82.17,60.83 82.17,61.19 86.1,65.12 86.1,65.45 86.24,65.59 86.69,65.59 86.81,65.72 86.81,65.99 86.69,66.12 86.25,66.12 86.12,66.24 86.12,66.52 86.25,66.64 86.69,66.64 86.81,66.77 86.81,69.7
  BOTTOM w0.102: v1(87.39,81.87) 87.85,82.33 U21.AR37
M_A_DQ36: length 40.7
  TOP w0.14: v1(73.68,53.07) 73.68,53.08 U9.G2
  IN3 w0.102: v1(73.68,53.07) 74.27,52.66 79.69,52.66 ; 88.39,69.39 88.66,69.66 88.66,74.84 87.33,76.16 87.29,76.16 86.63,76.82 86.63,78.5 86.79,79.02 86.79,79.51 86.91,80.13 86.98,80.65 v1(87.39,81.16)
  IN3 w0.127: 79.69,52.66 83.87,56.83 83.87,60.98 88.09,65.2 88.09,69.1 88.39,69.39
  BOTTOM w0.14: v1(87.39,81.16) 87.85,81.62 U21.AT37
M_A_DQ37: length 41.4
  TOP w0.14: U9.F2 73.67,54.67 v1(73.68,54.67)
  IN3 w0.102: 86.2,69.75 86.14,69.81 86.14,74.85 85.85,75.14 85.85,75.35 86.04,75.54 86.04,75.68 85.9,75.82 85.75,75.82 85.34,75.42 84.55,75.42 84.45,75.51 84.45,75.72 84.61,75.87 85.12,75.87 85.29,76.04 85.29,78.5 84.93,78.87 84.93,79.99 84.49,80.42 84.49,80.74 85.02,81.27 v1(85.48,81.27) ; 80.66,56.45 80.11,55.9 80.11,55.71 79.46,55.06 76.45,55.06 76.34,55.16 76.34,55.73 76.23,55.85 76.06,55.85 75.94,55.73 75.94,55.16 75.84,55.06 74.07,55.06 v1(73.68,54.67)
  IN3 w0.127: 86.2,69.75 86.2,67.46 85.49,66.75 85.49,65.37 80.96,60.84 80.96,56.75 80.66,56.45
  BOTTOM w0.102: v1(85.48,81.27) 85.87,81.66 U21.AT41
M_A_DQ38: length 40.1
  TOP w0.14: v1(74.49,55.48) 74.49,55.17 74.4,55.08 U9.E3
  IN3 w0.102: 85.9,69.52 85.9,69.53 85.9,74.8 85.56,75.14 84.32,75.14 84.2,75.26 84.2,75.8 84.59,76.2 84.88,76.2 85.04,76.36 85.04,78.46 84.07,79.43 84.07,80.73 85.29,81.95 v1(85.51,81.95) ; v1(74.49,55.48) 74.69,55.48 74.82,55.61 74.82,55.98 74.94,56.1 75.11,56.1 75.23,55.98 75.23,55.46 75.33,55.35 75.53,55.35 75.63,55.46 75.63,55.97 75.75,56.09 76.37,56.09 76.59,55.87 79.46,55.87 80.04,56.45
  IN3 w0.127: 85.9,69.52 85.9,67.59 85.18,66.87 85.18,65.5 80.65,60.97 80.65,57.07 80.04,56.45
  BOTTOM w0.14: v1(85.51,81.95) 85.72,81.95 85.98,82.21 U21.AR41
M_A_DQ39: length 42.7
  TOP w0.14: U9.H3 73.68,52.28 v1(73.68,52.25)
  IN3 w0.102: 89.28,68.74 89.37,68.82 89.37,76.39 88.77,76.98 88.77,80.3 v1(88.33,80.74) ; v1(73.68,52.25) 74.08,51.85 74.79,51.85 75.11,52.16 76.34,52.16 77.47,51.03 80.5,51.03
  IN3 w0.127: 80.5,51.03 85.18,55.72 85.18,61 89.01,64.82 89.01,68.46 89.28,68.74
  BOTTOM w0.127: v1(88.33,80.74) 88.38,80.74 88.8,80.32 U21.AW35
M_A_DQ40: length 24.5
  IN3 w0.102: v1(83.82,73.68) 83.38,73.24 83.38,72.89 83.15,72.67 83.15,71.9 82.61,71.36 82.61,70.66 ; 74.08,58.89 74.08,56.71 v1(73.67,56.29)
  IN3 w0.127: 74.08,58.89 74.08,58.9 78.85,63.67 79.08,63.67 82.16,66.75 82.16,70.21 82.61,70.66
  BOTTOM w0.089: U21.BJ44 84.4,75.25 84.4,74.26 v1(83.82,73.68)
  BOTTOM w0.14: v1(73.67,56.29) U25.D7
M_A_DQ41: length 24.6
  IN3 w0.102: v1(78.48,56.28) 78.88,56.68 79.46,56.68 79.7,56.93 80.03,57.94
  IN3 w0.127: v1(85.39,72.79) 85.37,72.77 85.37,67.81 84.65,67.1 84.65,65.72 80.12,61.19 80.12,58.22 80.03,57.94
  BOTTOM w0.089: U21.BG39 86.75,76.11 86.67,76.03 86.67,75.79 86.76,75.63 86.76,75.33 86.37,74.93 86.17,74.07 86.1,73.79 86.04,73.6 v1(85.39,72.79)
  BOTTOM w0.14: v1(78.48,56.28) U25.C2
M_A_DQ42: length 23.6
  IN3 w0.102: v1(85.39,74.09) 84.94,74.09 84.66,73.81 84.66,70.45 ; 78.92,58.89 78.92,58.63 78.61,58.31 77.75,58.31 77.67,58.39 v1(77.67,58.72)
  IN3 w0.127: 84.66,70.45 84.66,67.98 84.04,67.37 84.04,65.97 78.92,60.85 78.92,58.89
  BOTTOM w0.089: v1(85.39,74.09) 85.6,74.09 85.79,74.27 85.79,74.88 86.22,75.32 86.22,75.66 86.32,75.77 86.32,76.09 U21.BG40
  BOTTOM w0.14: v1(77.67,58.72) 77.67,58.48 77.46,58.28 U25.A3
M_A_DQ43: length 23.6
  IN3 w0.102: 79.21,58.53 78.88,58.2 78.88,57.63 78.75,57.5 78.13,57.5 78.07,57.44 78.07,57.19 77.98,57.09 v1(77.67,57.09)
  IN3 w0.114: 79.21,58.53 79.26,58.58 79.38,58.58
  IN3 w0.127: v1(85.39,73.44) 85.3,73.44 84.93,73.07 84.93,72.51 84.98,72.45 84.98,67.86 84.35,67.22 84.35,65.85 79.82,61.32 79.82,58.85 79.55,58.58 79.38,58.58
  BOTTOM w0.089: U21.BJ40 86.49,75.34 85.96,74.81 85.96,74.16 85.79,73.98 85.79,73.58 85.64,73.44 v1(85.39,73.44)
  BOTTOM w0.14: v1(77.67,57.09) 77.28,56.7 U25.C3
M_A_DQ44: length 23.8
  IN3 w0.102: v1(74.49,57.92) 74.49,58.1 74.99,58.61 74.99,58.89
  IN3 w0.127: 74.99,58.89 74.99,59.15 82.47,66.63 82.47,70.08 82.91,70.53 82.91,71.32 83.39,71.8 83.39,72.6 v1(83.82,73.03)
  BOTTOM w0.089: U21.BG43 84.92,76.46 84.92,76.15 84.76,75.98 84.76,75.8 84.91,75.65 84.91,75.33 84.58,75 84.58,73.79 v1(83.82,73.03)
  BOTTOM w0.14: v1(74.49,57.92) 74.48,57.92 74.12,58.28 U25.A7
M_A_DQ45: length 25.4
  IN3 w0.102: 73.29,58.89 73.27,58.87 73.27,57.49 v1(73.68,57.08) ; v1(83.82,74.32) 83.16,73.67 83.16,72.98 82.94,72.76 82.94,72.03 82.34,71.43 82.34,70.84
  IN3 w0.127: 73.29,58.89 73.29,59.29 78.09,64.08 79.06,64.08 81.86,66.88 81.86,70.36 82.34,70.84
  BOTTOM w0.089: U21.BG44 84.46,76.09 84.46,75.75 84.32,75.61 84.22,75.41 84.22,74.43 84.12,74.32 v1(83.82,74.32)
  BOTTOM w0.14: U25.B8 v1(73.68,57.08)
M_A_DQ46: length 24.3
  IN3 w0.102: 72.46,58.89 72.46,57.62 v1(72.87,57.08)
  IN3 w0.127: v1(83.82,74.97) 83.39,74.54 82.88,73.72 82.72,72.85 82.19,71.62 81.55,70.24 81.23,67.42 81.23,67.24 81.17,67.11 80.8,66.26 80.8,66.25 78.94,64.39 77.96,64.39 73.48,59.91 72.67,59.12 72.46,58.89
  BOTTOM w0.089: v1(83.82,74.97) 83.97,75.31 U21.BH45
  BOTTOM w0.14: U25.C8 73.27,56.68 v1(72.87,57.08)
M_A_DQ47: length 25.9
  IN3 w0.102: v1(85.39,74.74) 84.47,74.74 84.32,74.58 84.32,70.51
  IN3 w0.127: v1(78.48,59.01) 78.48,59.07 78.36,59.19 77.29,59.19 77.17,59.32 77.17,59.53 77.29,59.65 78.3,59.65 78.48,59.83 78.48,60.08 78.36,60.2 78.13,60.2 78.06,60.27 78.06,60.42 83.74,66.1 83.74,67.79 83.86,67.92 84.14,67.92 84.27,68.05 84.27,68.3 84.14,68.43 83.86,68.43 83.74,68.56 83.74,68.81 83.86,68.94 84.13,68.94 84.26,69.06 84.26,69.32 84.13,69.45 83.86,69.45 83.74,69.57 83.74,69.76 84.32,70.34 84.32,70.51
  BOTTOM w0.089: U21.BH41 86.03,75.38 85.77,75.11 85.49,75.11 85.39,75.01 v1(85.39,74.74)
  BOTTOM w0.14: U25.A2 78.08,58.61 v1(78.48,59.01)
M_A_DQ48: length 29.3
  TOP w0.14: v1(76.85,58.72) 77.28,58.29 U9.A7
  IN1 w0.102: v1(89.27,79.82) 88.9,79.82 88.74,79.66 88.74,76.69 88.01,75.96 86.56,75.96 85.79,75.19 85.79,72.62 85.24,72.07 85.24,70.01 84.57,69.34 84.57,68.3 76.3,60.02 76.3,58.83 76.41,58.72 v1(76.85,58.72)
  BOTTOM w0.14: v1(89.27,79.82) 89.6,79.82 89.72,79.7 U21.BA34
M_A_DQ49: length 28.3
  TOP w0.14: v1(78.48,57.9) 78.08,57.5 U9.B8
  IN1 w0.102: v1(78.48,57.9) 78.07,58.31 78.07,59.57 77.96,59.69 77.48,59.69 77.36,59.8 77.36,60.03 77.48,60.14 77.96,60.14 78.07,60.26 78.07,60.97 85.16,68.05 85.16,69.34 85.65,69.83 85.65,71.9 86.2,72.46 86.2,75.02 86.73,75.55 88.48,75.55 89.79,76.86 89.79,77.3 v1(89.35,77.75)
  BOTTOM w0.14: U21.BE34 89.7,77.39 v1(89.35,77.75)
M_A_DQ50: length 30.6
  TOP w0.14: U9.C8 78.48,57.08 v1(78.48,57.09)
  IN1 w0.102: v1(89.35,78.46) 89.99,77.81 89.99,76.77 88.57,75.35 86.81,75.35 86.4,74.94 86.4,72.35 85.85,71.8 85.85,69.74 85.45,69.34 85.45,67.93 78.88,61.37 78.88,61.06 78.77,60.94 78.5,60.94 78.37,60.81 78.37,60.61 78.5,60.48 79.01,60.48 79.14,60.36 79.14,60.15 79.01,60.03 78.46,60.03 78.34,59.9 78.34,59.7 78.46,59.57 78.77,59.57 78.88,59.46 78.88,57.5 v1(78.48,57.09)
  BOTTOM w0.14: v1(89.35,78.46) 89.42,78.46 89.72,78.15 U21.BD34
M_A_DQ51: length 29.6
  TOP w0.14: U9.C3 74.08,56.65 74.48,56.24 v1(74.48,56.25)
  IN1 w0.102: v1(74.48,56.25) 74.26,56.25 74.08,56.43 74.08,59.98 81.26,67.15 81.26,68.59 83.31,70.64 83.31,75.04 83.65,75.38 84.57,75.38 86.94,77.75 v1(87.3,77.75)
  BOTTOM w0.14: U21.BD37 87.85,77.85 87.64,77.64 87.41,77.64 v1(87.3,77.75)
M_A_DQ52: length 31
  TOP w0.14: v1(72.85,56.3) 73.23,56.68 U9.C2
  IN1 w0.102: v1(72.85,56.3) 73.27,56.72 73.27,60 79.99,66.72 79.99,67.66 80.45,68.12 80.81,69.34 80.83,69.42 80.96,69.64 81.3,71.29 81.58,71.82 82.52,73.62 82.52,75.25 84.2,76.93 84.2,76.97 84.47,77.24 87.26,78.86 87.5,78.86 v1(88.32,79.3)
  BOTTOM w0.14: v1(88.32,79.3) 88.28,79.3 87.85,78.88 U21.BB37
M_A_DQ53: length 30.5
  TOP w0.14: U9.A3 74.48,58.68 v1(74.49,58.68)
  IN1 w0.102: v1(87.29,77.03) 86.52,77.03 84.43,74.93 84.43,70.42 83.93,69.92 83.53,69.92 83.36,70.09 83.18,70.09 82.69,69.61 82.69,69.43 83.24,68.88 83.24,68.7 83.12,68.58 82.94,68.58 82.38,69.14 82.21,69.14 82.09,69.02 82.09,68.86 82.66,68.29 82.66,68.14 82.52,68 82.37,68 81.82,68.55 81.65,68.55 81.54,68.43 81.54,68.26 82.08,67.71 82.08,67.57 75.06,60.54 75.06,60.17 74.96,60.07 74.72,60.07 74.6,59.95 74.6,59.78 74.72,59.66 74.96,59.66 75.06,59.56 75.06,59.24 v1(74.49,58.68)
  BOTTOM w0.14: v1(87.29,77.03) 87.26,77.03 86.93,77.36 U21.BE39
M_A_DQ54: length 30.4
  TOP w0.14: v1(73.68,58.68) U9.A2
  IN1 w0.102: v1(87.36,78.38) 87.26,78.38 86.94,78.06 86.46,78.06 84.81,76.4 84.36,76.4 83.09,75.13 83.09,72.74 82.99,72.63 82.6,72.63 82.49,72.52 82.49,72.29 82.6,72.18 82.97,72.18 83.09,72.05 83.09,71.82 82.99,71.72 82.6,71.72 82.49,71.61 82.49,71.38 82.6,71.26 82.97,71.26 83.09,71.14 83.09,70.84 82.78,70.52 82.61,70.52 82.4,70.73 82.22,70.73 82.08,70.58 82.08,70.4 82.29,70.19 82.29,70.03 82.13,69.87 81.97,69.87 81.8,70.04 81.62,70.04 81.47,69.9 81.47,69.72 81.64,69.55 81.64,69.39 80.98,68.72 80.98,68.25 80.29,67.56 80.29,66.6 73.68,59.99 v1(73.68,58.68)
  BOTTOM w0.14: v1(87.36,78.38) 87.24,78.38 86.96,78.1 U21.BD39
