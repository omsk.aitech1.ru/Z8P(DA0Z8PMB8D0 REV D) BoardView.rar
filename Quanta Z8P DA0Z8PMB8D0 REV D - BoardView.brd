# Allegro board Quanta Z8P DA0Z8PMB8D0 REV D - BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DMIC_CLK_C: length 2.2
  BOTTOM w0.14: CN3.1 61.94,110.45 v1(61.96,110.43) R280.2
DMIC_CLK_R: length 2.2
  TOP w0.127: R243.2 197.47,27.61 v1(197.62,27.77) 197.92,28.06 198.07,28.06 198.13,28 U15.3
DMIC_DAT: length 197.9
  TOP w0.127: v1(130.22,47.02) 130.32,46.91 137.34,46.91 137.62,47.2 150.42,47.2 156.9,40.72 156.92,40.7 157.8,40.7 159.03,39.46 168.33,39.46 177.93,29.86 192.32,29.86 193.32,28.86 v1(193.76,28.86) 193.99,28.63 R240.2
  IN1 w0.102: v1(64.49,111.68) 67.36,111.68 67.63,111.41 72.17,111.41 73.36,112.6 76.1,112.6 78.11,114.61 83.46,114.61 85.32,112.76 87.8,112.76 88.62,111.93 103.63,111.93 105.35,110.22 105.35,106.13 106.08,105.39 106.08,103.8 107.16,102.72 110.3,102.72 117.82,95.2 117.82,93.88 119.74,91.97 119.74,86.66 124.63,81.77 124.63,69.2 126.65,67.18 126.65,51.89 130.22,48.32 v1(130.22,47.02)
  BOTTOM w0.127: CN3.2 61.93,110.95 61.94,110.94 63.18,110.94 D13.2 63.66,111.42 64.07,111 64.3,111 64.41,111.12 64.41,111.6 v1(64.49,111.68)
DMIC_DAT_R: length 2.1
  TOP w0.127: U15.2 198.23,28.4 198.16,28.33 197.12,28.33 R240.1
DNBSWON#: length 168.9
  TOP w0.14: U16.123 135.08,32.86 134.56,33.38 134.56,36.33 134.73,36.5 134.73,37.92 v1(134.66,38)
  IN3 w0.102: v1(78.94,84.94) 78.59,84.59 77.95,84.59 77.62,84.26 73.93,84.26
  IN3 w0.127: v1(134.66,38) 134.04,38 133.52,38.51 131.34,38.51 129.68,40.17 128.96,40.17 128.69,40.44 126.28,40.44 125.16,41.57 119.54,41.57 116.72,38.75 116.72,37.76 115.29,36.33 114.59,36.33 114.11,35.84 108.73,35.84 106.94,34.05 104.8,34.05 103.95,34.9 97.77,34.9 96.76,33.88 90.26,33.88 89.47,34.68 81.01,34.68 80.21,33.88 54.8,33.88 48.06,40.63 48.06,45.22 45.91,47.37 45.91,61.37 46.47,61.93 46.47,64.68 62.75,80.96 66.03,80.96 66.72,81.65 69.35,81.65 70.3,82.6 71.48,83.78 71.64,83.93 73.6,83.93 73.93,84.26
  BOTTOM w0.102: v1(78.94,84.94) 79.33,84.55 U21.AK55
DUALDMIC_PWR: length 4.1
  TOP w0.508: R3.2 v1(60.69,126.37) ; R3.2 R4.2 ; R3.2 60.44,125.19 v1(59.86,124.61)
  BOTTOM w0.305: CN3.29 60.2,124.45 60.04,124.61 v1(59.86,124.61)
EC_FPBACK#: length 250.7
  TOP w0.14: v1(45.32,110.6) v1(45.32,111.64) 45.32,113.48 46.34,114.5 48,114.5 Q2.2 ; v1(144.31,21.17) 144.31,21.54 145.51,22.74 145.51,23.88 146.17,24.54 146.17,26.25 146.38,26.46 U16.86
  IN3 w0.127: v1(144.31,21.17) 143.96,21.17 143.32,20.53 138.31,20.53 138.04,20.81 138.04,21.34 137.78,21.6 136.1,21.6 135.34,20.83 133.97,20.83 132.32,22.48 130.58,22.48 127.87,25.2 123.37,25.2 123.1,24.94 122.78,24.94 119.36,21.52 119.36,16.21 118.8,15.65 84.74,15.65 81.74,12.65 41.94,12.65 32.08,22.5 29.26,22.5 23.86,27.9 23.86,32.84 24.78,33.76 24.78,38.19 23.65,39.33 23.65,41.06 23.44,41.27 23.44,56.46 23.35,56.55 23.35,70.31 25.13,72.09 25.13,74.95 24.73,75.35 24.73,78.23 25.89,79.39 25.89,85.84 26.53,86.48 26.53,90.08 29.66,93.22 34.73,93.22 38.37,96.86 42.45,96.86 44.78,99.19 44.78,106.31 45.32,106.86 45.32,110.59 v1(45.32,110.6)
EC_PWROK: length 199.1
  TOP w0.127: v1(135.3,29.81) 136.64,28.47 136.64,26.21 137.15,25.69 137.15,23.16 136.4,22.41 136.4,20.21 135.19,19 133.78,19 132.35,17.56 132.35,17.53 131.62,16.8 R481.1 132.02,16.34 132.65,15.7 132.96,15.7 133.08,15.83 U16.33
  TOP w0.14: R81.2 70.39,84.63 70.4,84.63 v1(70.84,84.19) 71.21,84.56 72.38,84.56 72.75,84.19 73.58,84.19 74.53,85.13 75.33,85.13 75.97,84.5 77.06,84.5 C79.1 78.01,84.5 79.94,84.5 80.84,85.4 81.46,85.4 v1(81.82,85.77)
  IN2 w0.127: v1(135.3,29.81) 133.03,32.08 128.13,32.08 126.85,33.37 126.26,33.37 125.14,34.48 125.14,37.38 v1(127.03,39.27)
  IN3 w0.127: v1(70.84,84.19) 70.84,83.85 69.14,82.16 63.23,82.16 45.83,64.76 45.83,62.18 45.4,61.76 45.4,47.16 47.55,45.01 47.55,40.42 54.59,33.37 80.42,33.37 81.22,34.17 89.26,34.17 90.05,33.37 96.97,33.37 97.99,34.39 103.74,34.39 104.59,33.54 107.15,33.54 108.94,35.33 114.32,35.33 114.81,35.82 115.5,35.82 117.23,37.55 117.23,38.54 119.75,41.06 124.95,41.06 126.74,39.27 v1(127.03,39.27)
  BOTTOM w0.102: U21.AG49 82.18,86.12 v1(81.82,85.77)
EC_TYPEC_CHG_HI: length 218
  TOP w0.127: v1(31.32,92.52) v1(31.32,93.3) 31.32,93.33 30.14,94.51 28.24,94.51 R49.2
  TOP w0.14: v1(141.8,23.57) 141.8,24.2 142.7,25.09 142.7,25.76 142.35,26.11 142.35,28.51 144.14,30.29 144.14,30.43 144.9,31.19 145.31,31.19 145.48,31.36 U16.97
  IN1 w0.102: v1(29.74,23.48) 30.82,23.48 37.3,17 37.3,16.55 37.82,16.03 37.82,14.14 38.79,13.18 81.54,13.18 84.52,16.16 115.4,16.16 118.86,19.62 118.86,21.73 122.12,24.99 122.66,24.99 123.34,25.67 129.26,25.67 131.68,23.25 135.42,23.25 136.09,22.57 140.27,22.57 141.27,23.57 v1(141.8,23.57)
  IN3 w0.127: v1(31.32,92.52) 29.72,92.52 27.8,90.6 27.8,87.03 26.4,85.63 26.4,75.93 25.98,75.52 25.98,72.18 25.24,71.44 25.24,71.44 23.86,70.06 23.86,56.76 23.94,56.67 23.94,41.48 24.15,41.27 24.15,39.54 25.29,38.4 25.29,33.54 24.37,32.63 24.37,28.5 29.15,23.72 29.5,23.72 v1(29.74,23.48)
EC_TYPEC_EN: length 208.5
  TOP w0.14: v1(29.2,91.36) 29.55,91.7 R56.2 v1(29.9,91.24) 29.9,91.04 30.09,90.85 30.09,90.52 29.93,90.36 U3.6 ; v1(145.98,23.66) 146.38,24.06 U16.80
  IN1 w0.102: v1(145.98,23.66) 145.49,24.14 141.54,24.14 140.18,22.78 136.19,22.78 135.5,23.47 131.75,23.47 129.35,25.87 123.25,25.87 122.58,25.2 122.04,25.2 118.65,21.81 118.65,19.7 115.31,16.37 84.44,16.37 81.45,13.38 38.87,13.38 38.03,14.23 38.03,16.11 37.51,16.63 37.51,17.08 30.62,23.97 v1(30.2,23.97)
  IN3 w0.127: v1(30.2,23.97) 29.25,23.97 24.62,28.6 24.62,32.52 25.54,33.44 25.54,38.51 24.41,39.64 24.41,41.38 24.2,41.59 24.2,56.78 24.12,56.86 24.12,69.52 25.29,70.69 26.04,70.69 26.23,70.89 26.23,75.37 26.65,75.79 26.65,85.52 29.32,88.2 29.32,90.79 29.2,90.91 v1(29.2,91.36)
ECAGND: length 8.9
  TOP w0.14: U16.75 147.9,22.06 147.93,22.1 149.58,22.1 L5.1 150.11,21.57 150.24,21.57 150.26,21.55 151.13,21.55 151.51,21.17 C267.2 151.51,20.44 150.99,19.92 150.99,19.18 v1(150.81,19.01) 150.71,18.91 150.71,18.52 150.18,17.99 C272.1
EDP_AUXN: length 87.1
  TOP w0.127: v1(101.35,84.92) 101.13,84.92 101.03,84.82 101.03,84.56 101.15,84.43 104.9,84.43 105.15,84.18 108.91,84.18 111.84,87.12 111.84,97.5 107.9,101.45 106.32,101.45 102.84,104.92 102.84,109.93 102.01,110.77 83.81,110.77 82.11,112.47 74.87,112.47 72.82,114.52 71.88,114.52 69.81,116.59 68.41,116.59 v1(68.22,116.4)
  BOTTOM w0.127: C286.1 64.95,121.41 64.95,121.77 65.13,121.95 66.44,121.95 67.42,120.97 67.42,116.93 67.76,116.59 68.03,116.59 v1(68.22,116.4) ; v1(101.35,84.92) 101.26,84.92 101.07,85.12 U21.AH9
EDP_AUXN_C: length 4.3
  BOTTOM w0.127: C286.2 R279.1 62.96,121.67 62.37,121.67 61.75,121.05 61.22,121.05 61.12,120.95 CN3.22
EDP_AUXP: length 87.2
  TOP w0.127: v1(100.57,84.91) 100.77,84.71 100.77,84.45 101.04,84.18 104.8,84.18 105.05,83.93 109.01,83.93 112.1,87.01 112.1,97.61 108.01,101.7 106.42,101.7 103.1,105.02 103.1,110.03 102.11,111.02 83.92,111.02 82.22,112.72 74.98,112.72 72.93,114.77 71.99,114.77 69.92,116.84 68.44,116.84 v1(68.22,117.06)
  BOTTOM w0.127: v1(68.22,117.06) 68,116.84 67.86,116.84 67.67,117.03 67.67,121.07 66.54,122.2 65.43,122.2 C285.1 ; v1(100.57,84.91) 100.57,85.18 U21.AH10
EDP_AUXP_C: length 4.3
  BOTTOM w0.127: CN3.23 61.17,121.45 61.31,121.31 61.64,121.31 62.27,121.93 63.01,121.93 R278.1 C285.2
EDP_HPD: length 5.2
  TOP w0.127: 64.12,132.67 v1(64.12,134.07)
  TOP w0.14: R1.1 R2.1 C1.2 63.17,132.68 63.18,132.67 Q1.2 64.12,132.67
EDP_HPD_R: length 11.9
  TOP w0.14: R1.2 59.55,131.9 v1(59.22,131.57) 58.76,131.11 58.76,129.36 59.22,128.9 59.22,123.02 v1(59.86,122.38)
  BOTTOM w0.14: v1(59.86,122.38) 59.93,122.45 CN3.25
EDP_RCOMP_N: length 1.5
  TOP w0.127: v1(103.54,85.79) 103.58,85.83 R74.1
  BOTTOM w0.127: v1(103.54,85.79) 103.2,86.13 U21.AG5
EDP_RCOMP_P: length 3.4
  TOP w0.127: R74.2 104.74,85.36 103.25,85.36 v1(102.84,85.77)
  BOTTOM w0.127: U21.AG6 102.54,86.28 102.84,85.97 v1(102.84,85.77)
EDP_TXN0: length 83.2
  TOP w0.127: v1(66.86,120.32) 66.67,120.13 66.67,119.8 65.7,118.83 65.7,116.99 66.86,115.83 69.85,115.83 71.67,114.01 72.44,114.01 74.63,111.82 81.68,111.82 83.99,109.51 87.11,109.51 87.52,109.1 94.24,109.1 97.57,105.77 97.91,105.77 100.2,103.48 102.45,103.48 105.03,100.9 107.73,100.9 111.03,97.6 111.03,95.67 109.76,94.4 109.76,90.58 110.91,89.44 110.91,86.95 108.68,84.73 102.18,84.73 101.56,85.35 101.22,85.35 v1(100.76,85.81)
  BOTTOM w0.102: U21.AG9 101.07,86.11 v1(100.76,85.81)
  BOTTOM w0.127: C288.1 65.39,119.39 66.26,119.39 66.67,119.79 66.67,120.14 v1(66.86,120.32)
EDP_TXN0_C: length 3.9
  BOTTOM w0.127: CN3.19 61.07,119.45 61.18,119.56 64.1,119.56 C288.2
EDP_TXN1: length 91.8
  TOP w0.127: v1(66.25,117.53) 66.25,117.7 66.44,117.89 69.58,117.89 72.2,115.28 73.15,115.28 75.14,113.29 82.51,113.29 84.21,111.59 102.35,111.59 103.67,110.27 103.67,107.58 104.2,107.06 104.2,104.81 106.6,102.4 109.14,102.4 109.67,101.87 109.67,100.75 112.67,97.75 112.67,86.84 110.22,84.38 110.22,82.84 109.85,82.47 105.54,82.47 104.15,83.86 100.95,83.86 100.11,84.7 100.11,84.97 99.71,85.38 99.71,85.71 99.81,85.81 v1(100.05,85.81)
  BOTTOM w0.102: U21.AG10 100.35,86.11 v1(100.05,85.81)
  BOTTOM w0.127: v1(66.25,117.53) 66.25,117.74 66.14,117.85 65.55,117.85 65.15,118.25 63.34,118.25 63.26,118.17 63.26,117.95 C290.1
EDP_TXN1_C: length 2.2
  BOTTOM w0.127: C290.2 62.37,118.06 61.21,118.06 61.1,117.95 CN3.16
EDP_TXN2: length 61.2
  TOP w0.127: v1(67.58,112.53) 67.81,112.76 67.81,113.04 68.06,113.29 68.62,113.29 69.88,112.02 69.88,111.51 72.78,108.62 78.68,108.62 80,107.3 80.75,107.3 81.62,106.43 86.6,106.43 87.94,105.09 92.89,105.09 95.08,102.89 95.95,102.89 96.56,102.28 97.39,102.28 99.55,100.12 101.34,100.12 102.01,99.45 102.01,98.9 104.89,96.01 104.89,88.47 104.32,87.89 103.79,87.89 v1(103.57,87.67)
  BOTTOM w0.102: v1(103.57,87.67) 103.23,87.32 U21.AC5
  BOTTOM w0.127: C294.1 65.67,116.67 65.83,116.67 67.82,114.68 67.82,112.77 v1(67.58,112.53)
EDP_TXN2_C: length 3.9
  BOTTOM w0.127: CN3.13 61.13,116.45 61.24,116.56 64.1,116.56 C294.2
EDP_TXN3: length 70.6
  TOP w0.127: v1(66.26,112.4) 66.42,112.55 66.42,113.28 67.19,114.05 69.11,114.05 70.65,112.52 70.65,111.83 72.95,109.53 79.25,109.53 80.23,108.55 80.81,108.55 81.95,107.42 86.69,107.42 88.26,105.85 93.2,105.85 95.4,103.66 96.26,103.66 96.67,103.25 97.72,103.25 99.45,101.52 101.29,101.52 104.36,98.44 104.36,97.55 105.91,96 106.69,96 107.91,94.79 107.91,89.34 107.29,88.72 106.15,88.72 104.41,86.97 101.84,86.97 101.59,87.22 101.59,87.52 v1(101.42,87.69)
  BOTTOM w0.102: v1(101.42,87.69) 101.07,87.33 U21.AC9
  BOTTOM w0.127: v1(66.26,112.4) 66.41,112.55 66.41,114.01 65.49,114.93 63.7,114.93 C299.1
EDP_TXN3_C: length 2.2
  BOTTOM w0.127: CN3.10 61.11,114.95 61.22,115.06 62.37,115.06 C299.2
EDP_TXP0: length 83.2
  TOP w0.127: v1(101.45,85.79) 101.48,85.79 101.64,85.63 102.29,84.98 108.58,84.98 110.65,87.06 110.65,89.33 109.51,90.48 109.51,94.51 110.78,95.77 110.78,97.49 107.62,100.65 104.92,100.65 102.34,103.22 100.09,103.22 97.8,105.51 97.47,105.51 94.13,108.85 87.42,108.85 87,109.26 83.88,109.26 81.57,111.57 74.53,111.57 72.33,113.76 71.57,113.76 69.75,115.58 66.76,115.58 65.45,116.88 65.45,118.94 66.41,119.9 66.41,120.09 66.18,120.32 v1(66.04,120.32)
  BOTTOM w0.102: v1(101.45,85.79) 101.37,85.87 101.37,86.21 101.53,86.38 101.68,86.38 U21.AG7
  BOTTOM w0.127: C287.1 64.87,119.83 64.87,119.72 64.95,119.64 66.16,119.64 66.42,119.9 66.42,120.11 66.2,120.32 v1(66.04,120.32)
EDP_TXP0_C: length 4
  BOTTOM w0.127: C287.2 64.08,119.82 61.25,119.82 61.12,119.95 CN3.20
EDP_TXP1: length 91.8
  TOP w0.127: v1(66.25,118.34) 66.44,118.15 69.69,118.15 72.3,115.53 73.26,115.53 75.25,113.55 82.61,113.55 84.31,111.85 102.45,111.85 103.92,110.37 103.92,107.69 104.45,107.16 104.45,104.91 106.71,102.66 109.24,102.66 109.92,101.98 109.92,100.86 112.92,97.86 112.92,86.73 110.47,84.28 110.47,82.74 109.95,82.22 105.43,82.22 104.05,83.61 100.85,83.61 99.86,84.59 99.86,84.87 99.45,85.27 99.45,85.6 v1(99.29,85.77)
  BOTTOM w0.102: v1(99.29,85.77) 99.64,86.12 U21.AG12
  BOTTOM w0.127: v1(66.25,118.34) 66.01,118.1 65.66,118.1 65.26,118.5 63.67,118.5 C289.1
EDP_TXP1_C: length 2.2
  BOTTOM w0.127: CN3.17 61.15,118.45 61.28,118.32 62.35,118.32 C289.2
EDP_TXP2: length 61.2
  TOP w0.127: v1(68.24,112.53) 68.07,112.7 68.07,112.94 68.16,113.04 68.51,113.04 69.63,111.92 69.63,111.41 72.67,108.37 78.57,108.37 79.9,107.05 80.64,107.05 81.52,106.17 86.5,106.17 87.83,104.83 92.78,104.83 94.98,102.64 95.84,102.64 96.45,102.03 97.29,102.03 99.45,99.87 101.23,99.87 101.75,99.35 101.75,98.79 104.64,95.91 104.64,88.57 104.21,88.14 103.01,88.14 102.84,87.98 v1(102.84,87.68)
  BOTTOM w0.102: U21.AC6 102.49,87.33 v1(102.84,87.68)
  BOTTOM w0.127: v1(68.24,112.53) 68.07,112.69 68.07,114.79 65.94,116.92 65.48,116.92 C291.1
EDP_TXP2_C: length 4
  BOTTOM w0.127: C291.2 64.08,116.82 61.29,116.82 61.16,116.95 CN3.14
EDP_TXP3: length 70.6
  TOP w0.127: v1(102.12,87.7) 101.94,87.7 101.84,87.61 101.84,87.33 101.94,87.23 104.3,87.23 106.05,88.97 107.19,88.97 107.66,89.44 107.66,94.68 106.59,95.75 105.81,95.75 104.11,97.45 104.11,98.34 101.18,101.26 99.35,101.26 97.62,102.99 96.57,102.99 96.16,103.4 95.29,103.4 93.1,105.6 88.15,105.6 86.59,107.16 81.84,107.16 80.7,108.3 80.12,108.3 79.15,109.27 72.84,109.27 70.39,111.72 70.39,112.41 69.01,113.8 67.3,113.8 66.67,113.17 66.67,112.66 v1(66.93,112.4)
  BOTTOM w0.102: U21.AC7 101.78,87.19 101.86,87.1 102.1,87.1 102.18,87.19 102.18,87.63 v1(102.12,87.7)
  BOTTOM w0.127: C295.1 63.49,115.25 63.57,115.18 65.59,115.18 66.66,114.11 66.66,112.66 v1(66.93,112.4)
EDP_TXP3_C: length 2.2
  BOTTOM w0.127: C295.2 62.38,115.34 61.21,115.34 61.1,115.45 CN3.11
EDP_VDD_EN: length 21.7
  IN3 w0.127: v1(75,107.52) 74.87,107.64 67.31,107.64 66.56,108.39 v1(66.56,109.2)
  BOTTOM w0.127: U19.3 65.71,108.76 66.12,109.17 66.12,109.56 R281.2 66.57,109.21 v1(66.56,109.2)
  BOTTOM w0.14: v1(75,107.52) 75.75,108.27 76.7,108.27 77.55,107.41 77.55,104.62 78.08,104.1 Q27.6 78.08,102.73 78.21,102.59 R336.1
EMMC_CLK: length 40.8
  IN3 w0.127: v1(78.28,88.75) 77.83,89.2 75.96,89.2 71.14,94.03 71.14,94.8 69.6,96.33 63.91,96.33 60.27,92.7 59.86,92.7 59.51,93.05 57.87,93.05 56.57,94.35 v1(53.89,94.35)
  BOTTOM w0.102: U21.Y58 77.91,89.12 v1(78.28,88.75)
  BOTTOM w0.127: R331.1 56.18,102.22 53.11,99.15 53.11,95.13 v1(53.89,94.35)
EMMC_CLK_R: length 5.1
  TOP w0.102: U2.W6 58.39,99.37 v1(58.04,99.02)
  BOTTOM w0.14: R331.2 58.44,102.22 v1(58.56,102.09) 58.28,101.81 58.28,100.74 C318.1 58.43,99.63 R355.2 58.42,99.4 v1(58.04,99.02)
EMMC_CMD: length 35.5
  TOP w0.102: v1(58.73,98.97) 58.89,99.13 U2.W5
  IN3 w0.127: v1(81.82,89.66) 81.82,91.62 81.23,92.22 81.23,96.54 79.85,97.91 77.56,97.91 73.66,101.81 70.52,101.81 69.97,102.36 68.34,102.36 67.58,103.12 64.7,103.12 62.21,100.63 60.13,100.63 58.73,99.23 v1(58.73,98.97)
  BOTTOM w0.102: v1(81.82,89.66) 81.47,89.31 U21.Y51
EMMC_DATA_0: length 33.5
  TOP w0.102: U2.H3 59.89,93.4 v1(60.07,93.22)
  TOP w0.127: TP5.1 79.07,90.47 78.43,90.47 v1(77.58,89.62)
  IN3 w0.127: v1(60.07,93.22) 60.07,93.83 60.21,93.96 60.69,93.96 60.82,94.09 60.82,94.4 60.69,94.52 59.92,94.52 59.8,94.65 59.8,94.96 59.92,95.08 61,95.08 61.13,95.21 61.13,95.51 61,95.64 60.23,95.64 60.11,95.77 60.11,96.04 60.23,96.17 60.83,96.17 60.97,96.31 60.97,96.77 61.1,96.9 61.4,96.9 61.53,96.77 61.53,96.32 61.67,96.18 61.95,96.18 62.09,96.32 62.09,96.77 62.22,96.9 62.52,96.9 62.65,96.77 62.65,96.31 62.79,96.17 63.02,96.17 63.7,96.84 69.62,96.84 71.59,94.88 71.59,94.62 75.68,90.53 76.68,90.53 v1(77.58,89.62)
  BOTTOM w0.127: v1(77.58,89.62) 77.58,89.63 77.91,89.96 U21.V58
EMMC_DATA_1: length 30.9
  TOP w0.127: v1(64.01,98.84) 64.01,98.47 63.68,98.14 63.68,94.11 61.2,91.62 60.33,91.62 59.39,92.55 U2.H4
  IN3 w0.127: v1(64.01,98.84) 65.37,98.84 65.8,99.28 69.26,99.28 70.73,97.81 70.97,97.81 71.72,97.06 73.89,97.06 76.6,94.35 76.6,93.53 78.27,91.86 v1(78.27,91.44)
  BOTTOM w0.127: U21.T58 78.27,91.42 v1(78.27,91.44)
EMMC_DATA_2: length 37.3
  TOP w0.127: v1(64.94,97.94) 64.94,97.58 64.72,97.36 64.72,93.4 61.38,90.06 59.2,90.06 58.85,90.4 58.85,91.02 58.18,91.69 58.18,92.88 58.89,93.59 U2.H5
  IN3 w0.127: v1(64.94,97.94) 65.76,97.94 66.59,98.76 68.77,98.76 69.9,97.64 69.9,97.49 70.4,96.99 71.14,96.99 71.56,96.57 72.11,96.57 72.5,96.18 73.25,96.18 74.25,95.17 74.25,94.12 74.9,93.47 75.26,93.47 75.78,93.99 75.96,93.99 76.17,93.77 76.17,93.59 75.48,92.9 75.48,92.72 75.7,92.51 75.88,92.51 76.36,92.99 76.55,92.99 76.77,92.77 76.77,92.57 76.45,92.25 76.45,92.07 76.66,91.85 76.84,91.85 77.17,92.18 77.36,92.18 77.55,91.99 v1(77.55,91.44)
  BOTTOM w0.127: U21.T59 77.2,91.09 77.55,91.44 v1(77.55,91.44)
EMMC_DATA_3: length 37.2
  TOP w0.079: 61.11,94.24 60.65,94.24 U2.J2
  TOP w0.127: v1(62.26,99.34) 62.12,99.2 62.12,94.8 61.55,94.24 61.11,94.24
  IN3 w0.127: v1(81.11,89.6) 81.11,90.12 79.97,91.26 79.97,92.61 80.47,93.1 80.61,93.1 80.89,93.39 80.89,96.34 79.7,97.54 77.49,97.54 74.51,100.52 73.28,100.52 72.96,100.84 70.77,100.84 69.76,101.85 64.17,101.85 62.26,99.95 v1(62.26,99.34)
  BOTTOM w0.102: v1(81.11,89.6) 81.47,89.96 U21.V51
EMMC_DATA_4: length 44.1
  TOP w0.079: 60.14,93.77 60.14,94.24 U2.J3
  TOP w0.102: 60.14,93.77 60.42,93.49 61.54,93.49 61.62,93.56
  TOP w0.127: v1(62.89,99.84) 62.89,99.24 62.64,98.99 62.64,94.59 61.62,93.56
  IN3 w0.127: v1(62.89,99.84) 64.4,101.35 69.53,101.35 71.15,99.73 71.35,99.73 71.9,100.28 72.08,100.28 72.3,100.06 72.3,99.88 71.75,99.33 71.75,99.13 71.94,98.94 72.14,98.94 72.62,99.41 72.79,99.41 73.01,99.19 73.01,99.01 72.54,98.54 72.54,98.34 72.68,98.2 73.36,98.2 73.49,98.33 73.49,99.97 73.63,100.11 74.41,100.11 74.71,99.81 74.71,99.33 74.58,99.2 74.18,99.2 74.05,99.07 74.05,98.33 74.18,98.2 76.23,98.2 77.47,96.96 78.93,96.96 79.72,96.17 79.72,91.17 80.38,90.51 v1(80.38,89.63)
  BOTTOM w0.102: v1(80.38,89.63) 80.76,90 U21.V52
EMMC_DATA_5: length 44.1
  TOP w0.079: 59.64,93.8 59.64,94.24 U2.J4
  TOP w0.127: 59.64,93.8 59.64,92.95 59.8,92.79 61.61,92.79 63.16,94.35 63.16,98.77 63.41,99.02 63.41,101.46 v1(62.85,102.02)
  IN3 w0.127: v1(62.85,102.02) 64.46,103.63 67.79,103.63 68.55,102.87 70.27,102.87 70.76,102.38 73.55,102.38 77.67,98.26 79.97,98.26 81.6,96.64 81.6,92.25 82.46,91.39 v1(82.46,89.6)
  BOTTOM w0.127: U21.Y49 82.18,89.32 v1(82.46,89.6)
EMMC_DATA_6: length 37.4
  TOP w0.079: U2.J5 59.14,94.24 59.14,93.32
  TOP w0.127: v1(64.65,99.35) 64.65,98.37 64.2,97.93 64.2,93.62 61.18,90.6 60.21,90.6 58.91,91.89 58.91,93.09 59.14,93.32
  IN3 w0.127: v1(64.65,99.35) 65.14,99.35 66.11,100.32 68.96,100.32 71.09,98.19 71.2,98.19 71.91,97.48 74.06,97.48 77.07,94.47 77.07,93.88 78.03,92.92 78.41,92.92 78.98,92.35 v1(78.98,89.62)
  BOTTOM w0.102: v1(78.98,89.62) 79.33,89.97 U21.V55
EMMC_DATA_7: length 37.4
  TOP w0.079: v1(58.15,93.57) 58.15,94.24 U2.J6
  IN3 w0.127: v1(78.31,89.62) 78.58,89.89 78.58,90.86 78.45,90.99 75.91,90.99 75.74,91.16 75.74,91.36 76.04,91.66 76.04,91.86 75.85,92.06 75.65,92.06 75.34,91.75 75.14,91.75 74.12,92.77 74.12,92.97 74.43,93.27 74.43,93.45 74.21,93.67 74.03,93.67 73.73,93.36 73.53,93.36 73.33,93.56 73.33,93.76 73.91,94.34 73.91,94.52 73.69,94.73 73.51,94.73 72.94,94.16 72.74,94.16 72.54,94.35 72.54,94.55 72.8,94.81 72.8,94.99 72.59,95.21 72.41,95.21 72.15,94.95 71.95,94.95 71.75,95.14 71.75,95.34 72.19,95.78 72.19,95.96 71.97,96.17 71.79,96.17 71.36,95.74 71.16,95.74 69.11,97.78 66.34,97.78 65.98,97.42 64.5,97.42 64.36,97.56 64.36,98.05 64.24,98.18 63.93,98.18 63.8,98.05 63.8,97.56 63.66,97.42 63.38,97.42 63.24,97.56 63.24,97.99 63.12,98.12 62.81,98.12 62.69,97.99 62.69,97.56 62.55,97.42 60.69,97.42 59.36,96.09 59.36,95.26 58.15,94.05 v1(58.15,93.57)
  BOTTOM w0.102: U21.V57 78.62,89.94 v1(78.31,89.62)
EMMC_ID0: length 27.8
  IN2 w0.127: v1(95.49,110.03) 94.34,108.88 89.12,108.88 88.79,108.56 88.79,103.74 92.8,99.73 92.8,98.35 90.23,95.78 90.23,95.48 v1(89.26,94.51)
  BOTTOM w0.102: U21.H34 89.54,94.79 v1(89.26,94.51)
  BOTTOM w0.127: v1(95.49,110.03) 95.36,109.9 95.36,109.1 R287.2 R295.1
EMMC_ID1: length 23.4
  IN2 w0.127: v1(91.38,110.09) 90.79,110.68 89.48,110.68 87.78,108.98 87.78,103.32 90.19,100.9 90.19,99.74 89.35,98.89 89.35,98.34 87.91,96.9 87.91,96.06 88.14,95.83 v1(88.38,95.83)
  BOTTOM w0.102: v1(88.38,95.83) 88.72,95.5 U21.F35
  BOTTOM w0.127: v1(91.38,110.09) 91.15,109.87 91.15,109.09 91.58,108.66 R283.2 R291.1
EMMC_RCLK: length 36.5
  TOP w0.14: U2.R5 58.53,97.49 v1(58.32,97.7)
  IN3 w0.127: v1(58.32,97.7) 59.82,97.7 60.5,98.38 60.5,98.81 60.63,98.94 60.94,98.94 61.06,98.81 61.06,98.38 61.2,98.24 62.03,98.24 64.62,100.84 69.22,100.84 72.18,97.87 75.36,97.87 75.53,97.7 75.53,97.5 75.21,97.19 75.21,96.99 75.41,96.79 75.61,96.79 75.99,97.18 76.17,97.18 76.39,96.96 76.39,96.78 76,96.4 76,96.2 76.2,96 76.4,96 76.71,96.32 76.91,96.32 77.74,95.49 77.74,95.33 77.54,95.14 77.54,94.94 77.74,94.74 77.94,94.74 78.27,95.08 78.47,95.08 79.42,94.12 79.42,90.75 79.66,90.51 v1(79.66,89.59)
  BOTTOM w0.102: U21.V54 80.05,89.97 v1(79.66,89.59)
  BOTTOM w0.127: v1(58.32,97.7) 58.32,97.71 R357.1
EMMC_RCOMP: length 2.5
  TOP w0.508: v1(76.84,89.63) 76.84,89.86 76.51,90.18 R58.2 v1(75.26,90.18)
  BOTTOM w0.305: U21.V59 77.2,89.98 76.88,89.66 76.86,89.66 v1(76.84,89.63)
EMMC_RST#: length 21.1
  TOP w0.127: v1(52.28,85.63) 52.34,85.68 D2.2
  TOP w0.14: D2.2 53.53,86.06 v1(54.2,86.73) 54.74,87.26 R63.2 ; U2.U5 59.14,98.24 v1(59.39,98.24)
  BOTTOM w0.14: v1(54.2,86.73) 52.92,88 52.92,89.9 53.97,90.95 56.86,90.95 59.87,93.96 59.87,97.75 v1(59.39,98.24)
EN: length 4.2
  TOP w0.14: v1(204.61,34.99) 204.61,34.78 R216.1 205.07,34.49 205.07,35.31 204.97,35.4 U12.7
  BOTTOM w0.14: v1(204.61,34.99) 205.11,34.5 206.14,34.5 R451.2
EQ1: length 5.1
  TOP w0.127: U12.17 205.97,40.24 206.27,40.54 207.79,40.54 R169.1 v1(209.16,41.09) R170.2
EQ2: length 4.3
  TOP w0.127: R171.2 206.96,40.97 206.85,41.09 R172.1 205.89,40.56 205.42,40.56 205.21,40.77 v1(204.63,40.77) 204.97,40.43 U12.19
FAN1_RPM: length 154.9
  TOP w0.127: v1(215.63,32.26) C218.1 216.25,32.68 216.21,32.72 R223.2 ; v1(139.76,18.19) 139.58,18.01 139.58,17.6 139.33,17.35 138.88,17.35 138.68,17.15 U16.47
  TOP w0.14: R223.2 216.67,33.72 216.67,34.3 216.19,34.79 v1(216.19,36.3)
  IN3 w0.14: v1(216.19,36.3) 216.89,35.61 220.26,35.61 220.88,34.99 226.12,34.99 226.56,34.55 229.25,34.55 230.69,33.1 232.88,33.1 233.1,32.88 233.1,16.53 229.24,12.67 188.12,12.67 183.02,17.76 182.36,17.76 181.44,16.85 180.58,16.85 180.2,17.23 180.2,17.99 180.54,18.33 180.54,18.92 180.16,19.3 173.68,19.3 170.83,22.15 154.93,22.15 152.41,19.64 150.61,19.64 149.03,18.06 148.19,18.06 146.25,20.01 144.15,20.01 143.71,19.57 140.12,19.57 139.84,19.29 139.84,18.27 v1(139.76,18.19)
  BOTTOM w0.127: CN10.2 219.42,35.8 218.57,34.96 216.67,34.96 215.63,33.91 v1(215.63,32.26)
FAN_PWM: length 112.3
  TOP w0.127: v1(130.67,16.97) 130.5,17.14 130.5,17.82 130.74,18.06 U16.32 ; v1(214.75,36.38) 214.75,35.65 214.19,35.09 Q16.1 ; v1(163.97,19.59) 163.97,20.3 169.4,25.74 v1(169.4,27.26) 169.4,28.99 v1(169.45,29.04)
  IN1 w0.102: v1(169.45,29.04) 171.74,29.04 182.61,39.91 201.1,39.91 203.23,37.78 203.23,37.12 204.02,36.33 207.21,36.33 209.35,34.19 212.54,34.19 214.73,36.38 v1(214.75,36.38) ; v1(163.97,19.59) 163.97,13.7 162.04,11.77 152.49,11.77 152.28,11.97 152.28,13.34 150.81,14.81 132.07,14.81 130.67,16.21 v1(130.67,16.97)
FAN_PWM_Q: length 15.8
  TOP w0.127: R229.2 211.59,30.59 v1(211.67,30.51) ; R229.2 C216.1 211.59,32.97 211.9,33.28 Q16.3 ; R229.2 212.33,32.31 v1(214.96,32.31)
  BOTTOM w0.127: CN10.3 219.09,37.22 218.87,36.22 217.93,35.29 216.55,35.29 214.96,33.7 v1(214.96,32.31)
FCCM_A: length 16.7
  BOTTOM w0.254: PR103.1 111.05,129.24 111.05,133.22 110.1,134.17 102.52,134.17 101.36,135.34 PR90.2
FCCM_C: length 49.1
  BOTTOM w0.254: PR108.1 119.25,130.14 120.08,130.98 120.08,132.84 119.49,133.43 116.27,133.43 113.73,135.97 103.48,135.97 100.2,139.25 84.95,139.25 83.6,137.9 v1(83.6,135.77) 83.48,135.64 PR89.2
G5719LX1.24V:
  vias: v1(130.97,83.29)
GPC6: length 7.5
  TOP w0.14: R202.1 133.42,38.58 134.43,37.56 134.43,36.6 R207.1 133.97,35.47 v1(134.11,35.34) 134.28,35.17 134.28,33.26 134.68,32.86 U16.124
GPIO_23: length 4.8
  TOP w0.127: v1(93.38,98.77) 93.42,98.77 93.85,98.34 93.85,97.07 93.67,96.89 Q4.6 v1(92.23,96.89)
  BOTTOM w0.102: U21.B25 93.62,97.89 93.62,98.53 v1(93.38,98.77)
GPIO_24: length 22.3
  IN3 w0.14: v1(93.95,96.39) 95.27,97.71 95.27,98.77 96.42,99.91 101.77,99.91 102.14,100.28 102.14,102.29 v1(104.98,105.14)
  BOTTOM w0.102: U21.C25 93.94,96.46 93.94,96.39 v1(93.95,96.39)
  BOTTOM w0.127: v1(104.98,105.14) 105.4,105.14 106.8,106.54 108.48,106.54 108.7,106.76 Q25.5
GPIO_25: length 22
  IN3 w0.14: v1(92.94,95.85) 92.94,96.36 94.77,98.2 94.77,98.97 95.95,100.15 101.64,100.15 101.9,100.41 101.9,104.48 v1(102.38,104.97)
  BOTTOM w0.102: U21.C27 92.94,96.54 v1(92.94,95.85)
  BOTTOM w0.127: Q24.5 105.14,106.41 103.7,104.97 v1(102.38,104.97)
GPIO_34: length 4.9
  BOTTOM w0.102: R346.2 85.31,101.67 85.31,101.05 85.33,101.02 85.33,99.75 85.99,99.1 85.99,98.46 86.17,98.28 86.17,97.86 U21.B41
GPIO_35: length 7.1
  BOTTOM w0.102: 85.36,102.98 85.1,102.72 85.1,100.96 85.13,100.94 85.13,99.67 85.76,99.04 85.76,98.87 85.76,98.86 85.76,98.4 85.91,98.25 85.91,98.01 85.74,97.84 85.74,97.58 86.03,97.29 U21.C41
  BOTTOM w0.127: R313.2 85.36,102.98
GPIO_36: length 5.2
  TOP w0.127: R33.1 85.64,97.08 v1(86.4,97.08) 86.45,97.03 v1(86.45,95.89)
  TOP w0.14: R33.1 85.7,97.86 85.7,98.54 85.25,98.99 R27.1
  BOTTOM w0.102: v1(86.45,95.89) 86.06,95.5 U21.F41
GPIO_39: length 6.6
  BOTTOM w0.102: 82.78,102.98 R343.1 82.35,101.64 82.35,100.57 84.21,98.71 84.21,97.75 U21.B45
  BOTTOM w0.14: R310.1 82.78,102.98
GPIO_40: length 4.9
  BOTTOM w0.102: R334.2 81.36,101.12 81.36,100.12 81.66,99.81 82.48,99.81 83.71,98.58 U21.A46
GPIO_43: length 6.6
  BOTTOM w0.102: U21.B43 85.14,97.76 85.14,98.81 83.44,100.51 83.44,100.81 83.27,100.98 83.27,101.6 R344.1 83.74,102.98
  BOTTOM w0.127: R311.1 83.74,102.98
GPIO_44: length 6
  BOTTOM w0.102: 84.7,102.98 R345.1 84.23,101.6 84.23,100.93 84.29,100.87 84.29,100.22 85.48,99.03 85.48,98.2 U21.A42
  BOTTOM w0.127: R312.1 84.7,102.98
GPIO_47: length 6.2
  TOP w0.14: v1(86.45,95.14) 85.97,95.63 85.97,96.02 84.24,97.75 84.24,97.98 R32.2 83.12,99.1 R28.1
  BOTTOM w0.102: v1(86.45,95.14) 86.1,94.79 U21.H41
GPIO_48: length 2
  TOP w0.14: v1(86.48,93.74) 86.87,93.36 86.91,93.36 R54.2
  BOTTOM w0.102: U21.L41 86.1,93.37 v1(86.48,93.74)
GPIO_78: length 8.7
  BOTTOM w0.102: U21.K62 74.41,93.75 73.37,94.8 73.37,95.6 72.9,96.07 71.63,96.07 R364.2 71.1,96.95 71.21,97.06 v1(71.21,97.41) 70.8,97.82 70.79,97.82 70.76,97.86 70.39,97.86 70.32,97.79
  BOTTOM w0.127: 70.32,97.79 70.27,97.74 70.1,97.74 R360.2
GPIO_82: length 11.1
  TOP w0.14: v1(80.44,92.47) 80.25,92.66 79.58,92.66 79.32,92.92 76.57,92.92 74.69,91.04 72.45,91.04 72,90.59 R59.2
  BOTTOM w0.102: v1(80.44,92.47) 79.83,92.47 79.41,92.9 U21.M55
GPIO_88: length 15
  TOP w0.14: v1(78.23,92.5) 79.04,92.5 79.54,92 80.63,92 81.31,92.69 v1(81.31,93.53) 81.31,96.94 80.01,98.25 R31.1 79.93,98.27 79,99.19 76.48,99.19 R19.2
  BOTTOM w0.102: U21.M58 77.91,92.82 v1(78.23,92.5)
GPIO_92: length 7.2
  BOTTOM w0.102: U21.L63 74.49,93.29 73.01,94.77 v1(71.51,94.77) 71.28,94.77 71.1,94.96 R367.1 70.99,95.59 70.32,96.25
  BOTTOM w0.14: R363.1 70.32,96.25
GPIO_104: length 9.3
  TOP w0.14: R41.2 71.71,96.02 76.85,96.02 77.71,95.15 79,95.15 v1(79.08,95.07)
  BOTTOM w0.102: v1(79.08,95.07) 79.33,95.07 U21.F54
GPIO_105: length 11.4
  TOP w0.14: R43.2 71.22,94.25 71.53,93.95 72.84,93.95 72.99,93.8 75.41,93.8 75.91,94.29 76.64,94.29 77.22,94.87 78.57,94.87 78.85,94.59 79.41,94.59 79.79,94.98 79.79,95.51 80.09,95.8 v1(80.21,95.8)
  BOTTOM w0.102: v1(80.21,95.8) 80.52,95.5 U21.F52
GPIO_106: length 9.2
  TOP w0.14: v1(80.26,95.09) 80.68,95.5 80.68,96.08 80.51,96.25 79.33,96.25 77.15,98.43 v1(76.77,98.43) 76.1,98.43 74.8,99.74 R20.2
  BOTTOM w0.102: U21.H52 80.57,94.79 v1(80.26,95.09)
GPIO_110: length 12.7
  TOP w0.14: R16.1 74.98,101.22 75.28,100.92 75.28,99.65 76.02,98.91 77.21,98.91 78.82,97.31 R36.2 79.48,97.79 80.13,97.79 81.03,96.88 81.03,95.13 v1(80.31,94.41)
  BOTTOM w0.102: v1(80.31,94.41) 80.64,94.08 U21.J52
GPIO_111: length 10.6
  TOP w0.127: v1(71.05,99.59) R26.2
  TOP w0.14: R26.2 72.75,98.82 R29.2 72.75,98.28 73.63,97.41 77.02,97.41 77.27,97.16 77.27,96.02 77.62,95.68 78.26,95.68 v1(78.42,95.84)
  BOTTOM w0.102: U21.F58 78.27,95.69 v1(78.42,95.84)
GPIO_112: length 8.9
  TOP w0.14: R57.2 72.54,91.93 74.15,91.93 v1(74.33,91.75) 75,91.75 76.52,93.26 77.47,93.26 78.03,93.83 78.55,93.83 v1(79,93.39)
  BOTTOM w0.102: U21.K55 79.33,93.72 v1(79,93.39)
GPIO_113: length 7.9
  TOP w0.14: R39.2 71.22,96.8 71.51,97.08 72.88,97.08 v1(73.39,96.58)
  BOTTOM w0.102: v1(73.39,96.58) 73.95,96.02 73.95,95.3 74.55,94.7 75.09,94.7 75.25,94.54 75.65,94.54 75.78,94.67 75.98,94.67 76.36,95.05 76.36,95.48 U21.F61
GPIO_117: length 7.9
  TOP w0.14: v1(78.3,94.35) 78.15,94.35 77.34,93.53 76.24,93.53 75.02,92.31 73.29,92.31 v1(73.06,92.54) 72.35,92.54 72.22,92.41 R55.2
  BOTTOM w0.102: U21.H58 77.91,94.74 v1(78.3,94.35)
GPIO_120: length 7.9
  TOP w0.14: R18.1 73.33,99.37 73.33,98.53 R30.1 74,97.85 v1(75.2,97.85) 77,97.85 v1(78.34,96.51)
  BOTTOM w0.102: v1(78.34,96.51) 78.64,96.21 U21.E56
GPIO_121: length 5.7
  TOP w0.14: v1(76.85,96.98) 73.63,96.98 73.05,97.57 R35.2
  BOTTOM w0.102: v1(76.85,96.98) 77.24,96.59 U21.D59
GPIO_123: length 7
  BOTTOM w0.102: 70.32,98.63 v1(71.64,98.63) 73.15,98.63 75.03,96.75 75.58,96.75 U21.E62
  BOTTOM w0.14: R356.2 70.32,98.63
GPIO_RCOMP: length 1.9
  TOP w0.508: R34.2 89.43,96.72 89.25,96.54 v1(89.25,95.97)
  BOTTOM w0.305: U21.E34 89.49,96.21 v1(89.25,95.97)
H_CPU_SVIDCLK: length 44.5
  IN1 w0.102: v1(108.9,104.31) 110.87,106.29 110.87,114.32 115.71,119.15 118.14,119.15 118.64,119.65 118.64,121.55 119.56,122.47 v1(120.63,122.47)
  BOTTOM w0.102: 97.3,98.2 97.3,97.98 97.45,97.84 97.45,97.59 97.42,97.57 97.42,97.57 97.15,97.3 U21.C17
  BOTTOM w0.127: v1(108.9,104.31) 108.9,103.09 107.97,102.17 105.82,102.17 105.37,102.62 104.76,102.62 103.42,101.28 99.4,101.28 99.13,101.02 99.13,100.34 97.3,98.5 97.3,98.2 ; v1(120.63,122.47) PR122.2 120.09,123.12 119.68,122.71 PR123.2
H_CPU_SVIDDAT: length 46.3
  TOP w0.127: v1(120.63,123.76) PR27.2 119.73,123.12 119.25,123.59 PR24.1
  IN1 w0.102: v1(108.41,106.1) 108.41,107.48 110.16,109.24 110.16,114.61 115.57,120.02 117.59,120.02 117.89,120.32 117.89,123.04 118.61,123.75 119,123.75 119.43,123.32 120.18,123.32 v1(120.63,123.76)
  BOTTOM w0.102: U21.C18 96.69,97.66 96.4,97.96 96.4,98.26 96.65,98.51 96.65,98.54 98.69,100.58 98.69,101.28 99.15,101.74 99.46,101.74
  BOTTOM w0.127: v1(108.41,106.1) 106.73,106.1 105.31,104.67 104.86,104.67 104.52,104.33 104.52,103.82 R323.2 103.2,103.32 102.67,102.8 102.67,102.51 101.91,101.74 99.46,101.74
H_PROCHOT#: length 317.5
  TOP w0.14: PQ8.3 40.8,30 PR50.1 44.85,29.52 45.32,29.05 47.97,29.05 53.99,35.08 102.56,35.08 103.81,36.33 113.96,36.33 114.41,36.78 115.81,36.78 119.94,40.92 127.3,40.92 v1(127.76,41.38) 128.46,41.38 130.54,39.3 130.54,38.5 130.15,38.1 130.15,36.15 129.59,35.6 Q17.3 ; R17.1 77.19,99.47 79.12,99.47 79.58,99.01 80.77,99.01 81.61,98.18 81.85,98.18 82.83,97.2 v1(82.83,96.67)
  IN1 w0.102: v1(119.88,121.75) 119.12,120.99 119.12,119.45 118.34,118.67 117.94,118.67 115.91,118.67 111.41,114.17 111.41,103.34 119.04,95.7 119.04,94.39 122.66,90.78 122.66,86.64 125.86,83.45 125.86,69.78 129.2,66.43 129.2,53.96 131.68,51.48 131.68,49.3 130.83,48.45 130.83,45.98 129.81,44.96 129.81,43.42 v1(127.76,41.38)
  IN3 w0.127: v1(82.83,96.67) 83.21,97.05 83.21,98.62 82.26,99.57 82.26,103.52 81.88,103.9 81.88,108.22 73.55,116.56 73.55,120.26 71.53,122.28 71.53,123.63 65.65,129.51 65.65,132.3 67.42,134.07 71.44,134.07 77.08,139.7 100.05,139.7 103.65,136.1 110.3,136.1 112.89,133.51 112.89,131.08 115.37,128.6 117.71,128.6 119.38,126.93 119.38,122.25 v1(119.88,121.75)
  BOTTOM w0.102: U21.E47 83.2,96.3 v1(82.83,96.67)
  BOTTOM w0.14: PR127.2 v1(119.88,121.75)
HDA_BCLK_R: length 17.4
  TOP w0.127: R98.2 70.29,77.78 v1(71.86,79.35) 72.7,80.19 v1(72.7,81.7)
  IN3 w0.102: v1(83.34,83.95) 82.48,83.1 80.59,83.1 80.02,82.53 74.66,82.53
  IN3 w0.14: 74.66,82.53 74.15,82.02 73.02,82.02 v1(72.7,81.7)
  BOTTOM w0.127: v1(83.34,83.95) 83.32,83.95 82.94,83.57 U21.AM48
HDA_RST#_R: length 6.7
  TOP w0.127: v1(77.5,94.35) 77,93.85 76.05,93.85 75.48,93.28 72.15,93.28 R52.2
  BOTTOM w0.102: U21.K58 77.91,93.93 v1(77.5,94.35)
HDA_SDO_R: length 13.6
  TOP w0.127: v1(71.71,80.84) 71.71,80.14 70.52,78.95 R95.2
  IN3 w0.102: v1(79.72,83.98) 79.13,83.39 74.53,83.39
  IN3 w0.14: v1(71.71,80.84) 71.71,82.19 72.57,83.06 73.72,83.06 74.05,83.39 74.53,83.39
  BOTTOM w0.14: U21.AM54 80.05,83.65 v1(79.72,83.98)
HDA_SYNC_R: length 19.5
  BOTTOM w0.102: U21.AK58 77.91,84.22 77.57,83.88 76.44,83.88 76.28,83.73 76.27,83.73 76.26,83.72 76.06,83.72 76.06,83.73 76.04,83.73 75.92,83.85 75.67,83.85 75.36,83.55 74.95,83.55
  BOTTOM w0.127: R399.2 62.92,76.3 v1(63.16,76.55) 67.05,80.43 69.37,80.43 70.49,81.56 71.79,81.56 72.37,82.14 73.55,82.14 74.95,83.55
HDD+M2_PWR:
  vias: v1(229.3,32.16) v1(230.31,31.45) v1(230.27,29.55) v1(230.36,32.2) v1(230.35,30.57) v1(231.21,31.23) v1(232.4,30.71) v1(232.65,29.6) v1(232.65,28.61) v1(232.65,27.72) v1(232.65,26.9) v1(232.65,26.1) v2(228.21,31.78) v2(228.94,31.07)
HDMI_5V: length 19.7
  TOP w0.508: U5.1 24.45,74.68 23.43,73.67 22.72,73.67 22.29,73.23 v1(21.65,73.23) 21.63,73.23 21.39,73.47 19.38,73.47 18.96,73.05 v1(18.96,72.24) 18.38,72.24 18.26,72.36 R110.1 ; R116.1 18.36,69.79 18.59,70.02 v1(18.96,70.02)
  BOTTOM w0.508: v1(18.96,70.02) v1(18.96,72.24) 17.29,70.57 16.74,70.57 D30.1 16,70.57 15.47,70.57 C353.1 14.47,70.94 14.09,71.32 13.48,71.32 13.47,71.31 CN6.18
HDMI_DDCCLK: length 11.9
  TOP w0.127: CN6.15 11.84,70.5 11.84,71.64 12.16,71.95 12.97,71.95 13.35,71.57 13.35,71.58 v1(15.51,71.58) 15.73,71.58 15.99,71.33 16.24,71.33 D4.2 16.75,71.33 17.51,71.33 R110.2 18.84,71.58 18.96,71.7 R107.1 R108.1
HDMI_DDCCLK_SW: length 85.2
  TOP w0.127: v1(29.58,75.77) 29.58,75.22 29.41,75.05 R104.2 ; v1(27.9,71.08) 27.46,70.65 R120.2
  IN3 w0.127: v1(27.9,71.08) 27.9,74.73 28.94,75.77 v1(29.58,75.77) 29.19,76.16 29.19,76.99 29.04,77.14 28.58,77.14 28.45,77.27 28.45,77.52 28.58,77.65 29.04,77.65 29.19,77.8 29.19,78.01 29.04,78.16 28.58,78.16 28.45,78.29 28.45,78.54 28.58,78.67 29.04,78.67 29.19,78.82 29.19,79.32 30.24,80.38 30.24,82.25 35.5,87.51 35.5,88.9 36.86,90.26 36.86,92.3 39.15,94.59 45.21,94.59 45.81,95.19 50.68,95.19 51.03,95.54 51.03,96.31 53.26,98.55 53.26,99.58 58.98,105.3 72.64,105.3 77.23,100.7 78.81,100.7 79.21,100.3 v1(79.21,100.18)
  BOTTOM w0.102: U21.B49 82.24,97.79 81.73,97.79 81.23,98.29 81.23,98.5 80.72,99.02 80.45,99.02 79.28,100.18 v1(79.21,100.18)
HDMI_DDCDATA: length 11.9
  TOP w0.127: R115.1 R114.1 19.58,70.04 19.05,70.57 R116.2 17.66,70.82 16.75,70.82 D5.2 16.24,70.82 15.77,70.82 15.53,71.06 15.35,71.06 15.21,70.92 15.21,70.18 15.08,70.05 14.78,70.05 14.65,70.18 14.65,70.93 14.52,71.06 14.22,71.06 14.09,70.93 v1(14.09,70.21) 13.96,70.09 13.66,70.09 13.53,70.21 13.53,70.44 13.41,70.57 12.96,70.57 CN6.16
HDMI_DDCDATA_SW: length 85.1
  TOP w0.127: R121.2 28.89,69.98 28.89,69.14 29.01,69.02 29.33,69.02 29.45,69.14 29.45,70.73 29.18,71 R113.2 29.18,71.9 v1(29.58,72.29)
  IN3 w0.127: v1(29.58,72.29) 28.82,73.06 28.82,74.63 29.32,75.14 29.83,75.14 30.21,75.52 30.21,76.66 29.88,77 29.88,77.76 30.76,78.64 30.76,82.05 36.01,87.3 36.01,88.69 37.37,90.05 37.37,92.09 38.67,93.39 45.45,93.39 46.73,94.66 50.89,94.66 53.19,96.97 54.26,96.97 54.79,97.49 54.79,100.37 59.2,104.79 72.41,104.79 77.05,100.14 v1(78.54,100.14)
  BOTTOM w0.102: U21.C49 81.82,96.96 81.53,97.25 81.44,97.25 80.9,97.79 80.8,97.79 80.41,98.18 80.4,98.18 79.97,98.62 79.97,98.95 79.19,99.73 78.96,99.73 v1(78.54,100.14)
HDMI_EQ0: length 5.5
  TOP w0.127: U6.8 27.95,68.13 v1(27.24,68.84) ; v1(27.24,68.84) 27.06,68.66 25.26,68.66 24.95,68.97 R111.1 ; v1(27.24,68.84) 26.89,69.19 26.89,69.41 26.51,69.79 R119.1
HDMI_EQ1: length 4.4
  TOP w0.14: U6.2 30.95,68.34 30.85,68.45 v1(30.85,68.86) R118.1 30.51,69.67 30.39,69.8 30.39,71.32 30.26,71.45 R109.1
HDMI_HPD: length 9.3
  BOTTOM w0.127: CN6.19 12.03,71.81 13.32,73.11 14.96,73.11 D29.1 15.55,73.11 15.95,73.11 R400.1 R401.1 17.23,72.75 17.44,72.55 v1(17.69,72.55) 17.87,72.55 18.2,72.88 R402.1
HDMI_HPD_NOR: length 2.9
  TOP w0.127: v1(20.08,77.98) Q9.3 20.99,76.55 R99.1
HDMI_HPD_NOR-1: length 4.5
  TOP w0.127: v1(20,74.32) 19.81,74.51 19.42,74.52 Q9.2 v1(17.89,73.33)
  BOTTOM w0.127: v1(20,74.32) 19.56,74.32 19.42,74.18 R402.2
HDMI_HPD_RIN: length 10.9
  TOP w0.127: Q12.2 22.19,69.45 23.35,68.29 25.83,68.29 v1(26.13,67.99) ; U6.5 29.45,68.42 v1(29.91,68.87)
  IN1 w0.102: v1(26.13,67.99) 27,68.87 v1(29.91,68.87)
HDMI_HPD_RIN_Q: length 6.2
  TOP w0.127: Q12.3 23.56,72.42 24.4,73.26 v1(24.4,73.49) ; R100.1 22.31,76.3 v1(22.41,76.2)
  IN1 w0.102: v1(24.4,73.49) 22.41,75.47 v1(22.41,76.2)
HDMI_HPD_ROUT: length 24
  TOP w0.14: v1(30.1,61.84) 29.95,61.98 U6.21
  IN1 w0.102: v1(20.05,75.39) 21.03,74.42 21.03,71.27 26.41,65.88 26.41,62.93 27.16,62.18 27.67,62.18 28.31,62.82 29.2,62.82 30.1,61.92 v1(30.1,61.84)
  BOTTOM w0.127: v1(20.05,75.39) v1(18.45,75.39) 17.24,74.18 R401.2
HP-L2: length 5.2
  TOP w0.203: v1(206.06,27.14) 205.79,27.14 205.73,27.2 U15.32
  BOTTOM w0.508: C423.2 208.15,26.01 R466.2 R465.1 207.2,26.26 206.99,26.47 206.33,26.47 206.06,26.74 v1(206.06,27.14)
HP-L3: length 11.2
  BOTTOM w0.254: 209.15,19.81 208.85,19.52 CN17.31
  BOTTOM w0.508: R466.1 209.52,27.04 C417.2 209.53,26.41 v1(210.14,25.8) 210.14,24.98 210.63,24.49 210.63,21.29 209.15,19.81
HP-R2: length 15.5
  TOP w0.203: 206.33,27.6 U15.33
  TOP w0.254: R244.2 207.45,27.03 206.87,27.6 206.33,27.6
  TOP w0.508: v1(209.03,25.98) 208.66,26.34 208.05,26.34 207.75,26.65 R244.2
  IN3 w0.508: v1(207.24,20.45) 209.14,20.45 210.24,21.55 210.24,25.55 209.81,25.98 v1(209.03,25.98)
  BOTTOM w0.508: C444.2 206.26,20.47 206.28,20.45 v1(207.24,20.45) 207.24,21.07 R476.1
HP-R3: length 11.1
  TOP w0.508: R244.1 208.53,27.02 209.52,27.02 C243.2 209.53,26.57 209.72,26.37 v1(209.72,26.01) 209.72,25.53 v1(209.53,25.33)
  BOTTOM w0.254: CN17.33 207.85,19.68
  BOTTOM w0.508: v1(209.53,25.33) 209.53,24.73 210.02,24.24 210.02,21.85 207.85,19.68
HP_JD#: length 18.9
  TOP w0.254: v1(211.24,23.48) v1(210.69,22.93) 210.09,22.33 207.67,22.33 206.21,20.87 202.95,20.87 202.4,20.33 200.84,20.33 R257.2
  BOTTOM w0.254: v1(211.24,23.48) 211.24,21.52 213.35,19.4 CN17.22
HWPG: length 32.8
  TOP w0.203: 132.42,22.6 132.29,22.46 U16.21
  TOP w0.381: v1(134.78,24.36) 134.78,24.2 134.11,23.52 133.34,23.52 132.42,22.6
  BOTTOM w0.508: v1(134.78,24.36) 135.27,24.85 135.27,25.24 134.7,25.81 134.7,27.23 134.18,27.76 134.18,30.23 134.86,30.92 134.86,34.63 134.33,35.17 134.33,35.4 133.63,36.1 133.61,36.1 132.57,37.14 132.57,37.78 v1(132.25,38.11) 131.56,38.79 R443.1 D20.2 D19.2 D18.2 D17.2 D16.2 D15.2
HWPG_1.5V: length 6
  BOTTOM w0.203: PU14.1 134.92,45.04 PR186.2
  BOTTOM w0.254: D20.1 v1(131.56,44.25) 131.69,44.38 PR186.2
HWPG_1.05V: length 86.1
  TOP w0.508: v1(125.11,109.44) 124.41,108.74 117.98,108.74 115.85,106.61 115.85,101.6 121.23,96.22 121.23,93.29 121.83,92.69 121.83,88.93 121.26,88.36 121.26,80.71 128.82,73.15 128.82,65.61 v1(128.17,64.96)
  BOTTOM w0.508: PR144.2 PR145.2 v1(125.11,109.44) ; v1(128.17,64.96) 128.17,58.7 121.61,52.14 121.61,49.46 124.08,46.99 124.08,45.22 125.46,43.83 D17.1
HWPG_1.8V_S5: length 192.9
  TOP w0.508: v1(46.01,83.67) 46.9,83.67 48.74,81.83 48.74,77.5 49.13,77.12 49.13,72.31 43.07,66.26 43.07,56.68 40.99,54.6 40.99,49.26 43.09,47.15 v1(43.09,43.42)
  IN2 w0.508: v1(43.09,43.42) 42.09,42.41 42.09,39.26 49.47,31.88 100.66,31.88 101.8,33.02 107.79,33.02 110.29,35.52 114.2,35.52 114.71,36.03 116.62,36.03 121.96,41.38 v1(126.48,41.38)
  BOTTOM w0.508: PR165.2 PR160.2 46.05,83.71 v1(46.01,83.67) ; v1(126.48,41.38) 126.48,42.76 126.76,43.04 D18.1 127.49,45.27 128.8,46.58 128.8,47.91 129.17,48.27 129.17,56.97 130.1,57.9 130.1,67.32 126.73,70.7 126.73,79.52 128.19,80.98 130.83,80.98 132.32,82.47 PR163.2
HWPG_1.24V_S5: length 58.4
  TOP w0.508: v1(134.18,88.84) 133.98,88.84 v1(132.55,90.27)
  BOTTOM w0.508: v1(132.55,90.27) 132.55,91.33 132.12,91.77 PR149.2 PR152.2 ; D19.1 128.53,44.03 128.53,45.4 129.45,46.31 129.45,47.64 129.81,48 129.81,56.7 130.75,57.63 130.75,67.59 127.37,70.97 127.37,79.25 128.46,80.33 131.1,80.33 133.16,82.39 133.16,83.05 134.18,84.07 v1(134.18,88.84)
HWPG_1.35VSUS: length 39.4
  IN1 w0.254: v1(106.4,25.3) 106.97,25.87 106.97,28.12 108.22,29.37 109.85,29.37 110.68,30.21 113.18,30.21 117.04,34.06 123.82,34.06 126.22,36.46 v1(126.22,36.87)
  BOTTOM w0.254: D15.1 121.4,42.06 120.76,41.42 120.76,39.73 121,39.48 124.48,39.48 126.22,37.74 v1(126.22,36.87) ; v1(106.4,25.3) 106.78,24.92 PR197.2 PR196.1
I2C4_SCL: length 151.8
  TOP w0.127: v1(108.98,24.95) 109.69,25.66 109.69,30.91 109.38,31.22 109.38,32.33 108.66,33.05 107.63,33.05 v1(105.82,34.85) ; v1(79.66,82.06) 79.22,81.62 75.05,81.62 74.98,81.55 74.6,81.55 73.7,82.45 72.05,82.45 71.2,81.6 71.2,80.87 70.88,80.55 70.56,80.55 R92.2 70.63,79.96 v1(70.72,80.05) ; Q21.4 114.62,17.49 114.09,16.95 112.53,16.95 112.25,17.23 112.25,18.72 v1(111.87,19.11)
  IN3 w0.127: v1(108.98,24.95) 109.16,24.77 109.16,22.21 111.87,19.5 v1(111.87,19.11) ; v1(70.72,80.05) 69.59,80.05 69.22,79.68 63.28,79.68 47.82,64.22 47.82,47.29 49.36,45.76 49.36,41.16 55.34,35.18 79.71,35.18 80.48,35.95 89.99,35.95 90.79,35.15 96.23,35.15 97.27,36.2 104.54,36.2 105.82,34.91 v1(105.82,34.85)
  BOTTOM w0.102: U21.AP54 79.66,82.14 v1(79.66,82.06)
I2C4_SCL_C: length 13.2
  TOP w0.127: Q21.3 112.65,17.49 112.48,17.66 112.48,18.85 112.3,19.03 112.3,19.36 112.13,19.54 111.7,19.54 111.44,19.28 111.44,18.93 112.03,18.34 112.03,17.61 111.95,17.53 ESD4.6 ; R268.1 v1(112.53,16.44) 111.74,16.44 111.31,16.87 111.31,17.29 ESD4.6 ; ESD4.6 111.31,17.77 111.31,18.22 110.98,18.55 v1(110.98,19.51)
  BOTTOM w0.127: CN15.6 110.7,20.08 110.98,19.79 v1(110.98,19.51)
I2C4_SDA: length 148.6
  TOP w0.127: v1(108.98,25.75) 109.17,25.94 109.17,30.6 v1(107.08,32.68) 105.16,34.61 v1(105.16,34.85) ; Q21.1 113.3,19.21 113.17,19.33 v1(112.76,19.33) ; v1(80.39,82.04) 80.39,82.41 80.26,82.54 78.83,82.54 78.14,81.85 75.55,81.85 74.44,82.96 71.75,82.96 69.97,81.18 R90.2 70.21,80.98 70.31,81.08 v1(70.67,81.08)
  IN3 w0.127: v1(70.67,81.08) 69.88,81.08 69.2,80.39 66.56,80.39 66.36,80.2 63.07,80.2 47.32,64.45 47.32,47.06 48.84,45.54 48.84,40.95 55.13,34.66 79.91,34.66 80.69,35.44 89.78,35.44 90.58,34.64 96.44,34.64 97.47,35.67 104.34,35.67 v1(105.16,34.85) ; v1(108.98,25.75) 109.26,25.75 109.69,25.33 109.69,22.66 112.69,19.66 112.69,19.41 v1(112.76,19.33)
  BOTTOM w0.102: U21.AP52 80.39,82.17 v1(80.39,82.04)
I2C4_SDA_C: length 8.9
  TOP w0.127: Q21.6 114.63,18.79 114.46,18.95 114.46,19.05 R264.1 113.73,19.97 112.71,20.99 112.01,20.99 ESD4.1 111.99,20.1 112.86,20.1 v1(113.07,19.89)
  BOTTOM w0.127: v1(113.07,19.89) 112.86,20.1 112.17,20.1 111.7,20.57 CN15.5
ICMNT: length 159.3
  TOP w0.14: v1(129.6,37.86) 129.6,37.95 130.26,38.62 130.26,39.2 128.83,40.64 120.06,40.64 115.92,36.5 114.53,36.5 114.07,36.05 104.02,36.05 102.76,34.8 54.11,34.8 48.08,28.77 44.85,28.77 43.91,29.72 42.11,29.72 41.8,29.41 PR54.1 41.44,27.47 v1(41.14,27.17) ; U16.67 147.88,18.86 148.75,17.99 C272.2 149.47,17.54 150.11,17.54 151.27,18.7 151.27,19.82 152.56,21.12 152.56,23.07 153.56,24.06 153.56,27.38 153.86,27.68 155.04,27.68 155.57,28.21 v1(155.57,29.77) 155.57,30.4 154.95,31.02 154.95,31.7 v1(155,31.75) ; PU2.7 40.68,20.47 PC53.2 v1(40.03,21.77)
  IN2 w0.127: v1(129.6,37.86) 130.7,38.95 132.16,38.95 133.47,40.27 139.03,40.27 140.3,39.01 148.02,39.01 149.02,38 149.02,35.91 150.6,34.34 152.55,34.34 155,31.88 v1(155,31.75)
  IN3 w0.14: v1(41.14,27.17) 41.14,24.8 40.03,23.69 v1(40.03,21.77)
IMVP_PWRGD: length 92.7
  TOP w0.508: v1(128.17,65.98) v1(128.17,69.58) 128.17,72.86 120.62,80.42 120.62,88.63 121.19,89.21 121.19,92.41 120.58,93.02 120.58,95.97 115.21,101.34 115.21,106.87 119.9,111.55 119.9,118.68 120.63,119.41 v1(120.63,121.44)
  BOTTOM w0.508: D16.1 123.43,46.72 120.96,49.19 120.96,52.41 127.52,58.97 127.52,65.33 v1(128.17,65.98) ; PR130.2 119.37,120.48 120.37,120.48 PR129.2 v1(120.63,121.44)
INT_AMIC-VREFO: length 6
  TOP w0.203: 207.64,25.1 206.73,25.1 206.47,24.85 206.13,24.85 205.88,25.1 205.63,25.1 205.53,25.2 U15.27
  TOP w0.254: 207.64,25.1 C255.1 R251.2 v1(209.65,23.71)
INT_EDP_HPD#: length 48.5
  TOP w0.127: v1(66.92,130.38) 66.33,130.38 v1(66.15,130.56) 66.1,130.61 Q1.3
  IN3 w0.127: v1(82.12,92.32) 82.56,92.75 82.56,95.72 83.45,96.61 83.45,98.7 82.52,99.64 82.52,103.62 82.14,104 82.14,108.33 73.8,116.67 73.8,120.37 71.78,122.38 71.78,123.74 66.15,129.37 v1(66.15,130.56)
  BOTTOM w0.102: U21.P48 82.5,91.94 v1(82.12,92.32)
INT_HDMI_HPD#: length 83
  TOP w0.127: v1(25.56,77.32) 25.46,77.32 25.09,77.69 22.88,77.69 22.75,77.81 R100.2 21.47,77.81 R99.2
  IN3 w0.127: v1(30.35,77.49) 31.29,78.43 31.29,81.85 36.52,87.09 36.52,88.48 37.88,89.84 37.88,91.88 38.87,92.87 45.67,92.87 46.94,94.14 51.11,94.14 53.41,96.45 54.48,96.45 55.31,97.28 55.31,100.17 59.41,104.28 72.18,104.28 77.07,99.4 81.14,99.4 v1(81.85,98.68)
  BOTTOM w0.102: v1(81.85,98.68) 82.08,98.45 82.08,98.37 82.61,97.84 82.61,97.58 82.37,97.34 U21.C50
  BOTTOM w0.127: v1(25.56,77.32) 26.67,78.43 29.42,78.43 v1(30.35,77.49)
INT_HDMICLK+: length 165.9
  TOP w0.127: C111.1 36.51,69.77 36.25,69.77 v1(36.06,69.58) 35.88,69.76 35.37,69.76 35.27,69.66 C110.1
  IN1 w0.102: v1(36.06,69.58) 36.06,69.76 36,69.82 35.56,69.82 34.73,69 34.73,66.14 35.5,65.38 38.85,65.38 41.07,63.15 41.07,48.28 45.54,43.81 46.59,43.81 51.03,39.37 111.42,39.37 114.67,42.61 114.67,43.45 117.02,45.8 117.02,48.57 120.51,52.06 120.51,64.63 118.45,66.69 118.45,78.61 113,84.06 107.54,84.06 107.29,83.81 107.29,83.2 107.38,83.11 v1(107.57,83.11)
  BOTTOM w0.102: v1(107.57,83.11) 107.38,83.11 107.28,83.21 107.28,83.65 106.81,84.12 105.72,84.12 105.54,84.3 104.85,84.3 104.68,84.13 104.35,84.13 U21.AL2
INT_HDMICLK+_C: length 8.5
  TOP w0.127: v1(17.95,67.78) 18.27,68.11 18.63,68.11 18.73,68 R125.1
  BOTTOM w0.127: R404.1 18.73,68.03 18.6,68.15 18.08,68.15 17.95,68.03 v1(17.95,67.78) 17.6,68.13 16.34,68.13 16.23,68.02 ESD6.7 ESD6.4 14.73,68.02 14.59,68.15 13.83,68.15 13.32,67.65 13.04,67.65 CN6.10
INT_HDMICLK+_C_RIN: length 5.1
  TOP w0.127: U6.31 32.65,66.48 32.78,66.61 33.01,66.61 34.01,67.6 34.01,69.66 34.11,69.77 34.38,69.77 34.49,69.66 C110.2
INT_HDMICLK+_C_ROUT: length 8.9
  TOP w0.127: U6.10 26.72,66.48 26.6,66.6 26.3,66.6 25.93,66.98 25.71,66.98 25.58,67.1 24.95,67.1 v1(24.44,66.6) 23.9,67.14 22.86,67.14 21.91,68.09 19.85,68.09 R125.2
INT_HDMICLK+_NOR: length 23.3
  TOP w0.127: C111.2 38.04,69.82 38.2,69.82 v1(38.43,69.58) ; R126.1 v1(20.3,67.63)
  BOTTOM w0.127: v1(38.43,69.58) 38.34,69.68 38.01,69.68 37.73,69.4 37.73,69.39 36.57,68.23 33.56,68.23 31.98,69.8 25.13,69.8 22.97,67.65 21.85,67.65 21.34,68.16 20.83,68.16 v1(20.3,67.63) 20.18,67.75 R404.2
INT_HDMICLK-: length 165.9
  TOP w0.127: C108.1 36.5,70.02 36.27,70.02 v1(36.06,70.23) 35.85,70.01 35.43,70.01 35.27,70.18 C107.1
  IN1 w0.102: v1(36.06,70.23) 35.86,70.03 35.47,70.03 34.53,69.08 34.53,66.06 35.41,65.17 38.76,65.17 40.87,63.07 40.87,48.19 45.46,43.6 46.5,43.6 50.94,39.17 111.51,39.17 114.87,42.53 114.87,43.37 117.22,45.72 117.22,48.48 120.71,51.98 120.71,64.71 118.65,66.78 118.65,78.7 113.08,84.26 107.45,84.26 107.08,83.89 107.08,83.31 v1(106.88,83.11)
  BOTTOM w0.102: v1(106.88,83.11) 107.08,83.31 107.08,83.56 106.72,83.92 105.63,83.92 105.53,84.02 U21.AL1
INT_HDMICLK-_C: length 8.4
  TOP w0.127: v1(17.95,68.68) 18.27,68.36 18.59,68.36 18.73,68.5 R123.1
  BOTTOM w0.127: R123.1 18.73,68.53 18.6,68.41 18.08,68.41 17.95,68.53 v1(17.95,68.68) 17.65,68.38 16.39,68.38 16.26,68.52 ESD6.6 ESD6.5 14.67,68.52 14.56,68.41 13.72,68.41 13.22,67.9 12.94,67.9 12.7,68.14 CN6.12
INT_HDMICLK-_C_RIN: length 5.1
  TOP w0.127: U6.32 32.64,66.98 32.74,66.89 32.93,66.89 33.75,67.71 33.75,69.77 34.01,70.03 34.37,70.03 34.49,70.14 C107.2
INT_HDMICLK-_C_ROUT: length 8.9
  TOP w0.127: R123.2 19.87,68.35 22.02,68.35 22.97,67.4 23.97,67.4 v1(24.44,67.87) 24.95,67.36 25.68,67.36 25.81,67.23 26.03,67.23 26.41,66.86 26.55,66.86 26.67,66.98 U6.9
INT_HDMICLK-_NOR: length 23.3
  TOP w0.127: R122.1 20.34,68.79 v1(20.29,68.84) ; v1(38.43,70.24) 38.26,70.07 37.95,70.07 C108.2
  BOTTOM w0.127: v1(38.43,70.24) 38.12,69.93 37.9,69.93 37.48,69.5 37.48,69.5 36.46,68.49 33.66,68.49 32.09,70.06 25.03,70.06 22.87,67.9 21.96,67.9 21.44,68.41 20.71,68.41 v1(20.29,68.84) 20.16,68.71 R403.2
INT_HDMITX0N: length 160.6
  TOP w0.127: C122.1 35.27,60.99 35.43,60.82 35.85,60.82 v1(36.06,61.04) 36.27,60.83 36.5,60.83 C123.1
  IN1 w0.102: v1(107.74,85.96) 107.95,85.75 109.85,85.75 110.21,86.11 113.94,86.11 115.28,84.78 115.28,84.33 120.02,79.59 120.02,67.38 122.09,65.32 122.09,51.41 118.65,47.98 118.65,45.18 116.27,42.79 116.27,41.95 112.11,37.79 50.34,37.79 45.92,42.21 44.88,42.21 39.47,47.61 39.47,54.88 35.39,58.96 35.39,60.54 35.62,60.77 35.8,60.77 v1(36.06,61.04)
  BOTTOM w0.102: v1(107.74,85.96) 107.54,86.16 107.54,86.37 107.33,86.58 106.25,86.58 105.2,85.53 104.74,85.53 U21.AH2
INT_HDMITX0N_C: length 15.3
  TOP w0.127: v1(17.92,62.18) 18.25,61.86 18.63,61.86 18.73,61.96 R140.1 ; v1(13.3,62.1) 13,61.8 12.54,61.8 12.05,62.29 12.05,66.25 11.8,66.5 11.46,66.5 CN6.9
  BOTTOM w0.127: v1(13.3,62.1) 13.59,61.8 13.96,61.8 14.08,61.92 14.08,62.29 14.35,62.57 14.59,62.57 14.73,62.7 ESD7.2 ESD7.9 16.34,62.7 16.46,62.58 16.75,62.58 17.03,62.3 17.03,61.89 17.11,61.8 17.54,61.8 v1(17.92,62.18) 17.92,61.98 18.05,61.86 18.57,61.86 18.73,62.01 R140.1
INT_HDMITX0N_C_RIN: length 5
  TOP w0.127: U6.26 32.65,63.98 32.78,63.85 33.07,63.85 33.88,63.04 33.88,61.05 34.11,60.82 34.35,60.82 34.49,60.96 C122.2
INT_HDMITX0N_C_ROUT: length 9.6
  TOP w0.127: U6.15 26.7,63.98 26.53,63.81 26.38,63.81 26.07,63.51 26.07,62.47 25.88,62.27 25.53,62.27 v1(25.12,62.69) 24.7,62.27 23.44,62.27 23.02,61.85 19.87,61.85 R140.2
INT_HDMITX0N_NOR: length 22.6
  TOP w0.127: v1(38.43,61.05) 38.26,60.88 37.95,60.88 C123.2 ; R139.1 v1(20.3,62.34)
  BOTTOM w0.127: R409.2 20.18,62.21 v1(20.3,62.34) 20.76,61.87 23.84,61.87 25.31,60.41 33.69,60.41 34.83,59.26 36.31,59.26 37.81,60.77 38.15,60.77 v1(38.43,61.05)
