# Allegro board Quanta Z8P DA0Z8PMB8D0 REV D - BoardView.brd (continued)
## Nets (continued)
GND: C1.1 C2.1 C3.2 C4.1 C5.2 C6.1 C7.1 C8.1 C9.2 C10.1 C11.2 C12.2 C13.2 C14.2 C15.2 C16.2 C17.2 C19.2 C20.2 C21.2 C23.2 C24.2 C25.2 C26.2 C27.2 C29.2 C30.2 C31.2 C32.1 C33.1 C34.1 C35.1 C37.2 C38.2 C39.2 C40.1 C41.1 C42.2 C43.2 C44.2 C45.1 C46.1 C47.1 C48.2 C49.2 C52.1 C53.1 C54.1 C56.2 C57.2 C58.2 C59.2 C60.2 C61.2 C62.2 C63.2 C64.1 C65.1 C66.1 C67.2 C68.1 C69.1 C71.2 C72.2 C73.2 C74.2 C75.1 C76.2 C77.2 C78.2 C80.2 C81.1 C82.2 C83.2 C84.1 C85.1 C86.2 C87.1 C88.1 C89.1 C90.2 C91.1 C92.1 C93.2 C94.1 C95.1 C96.2 C98.1 C99.1 C100.1 C101.2 C103.2 C104.2 C105.1 C106.1 C109.1 C120.1 C121.2 C126.1 C127.1 C128.1 C129.1 C130.1 C131.1 C132.1 C133.1 C134.1 C135.2 C136.2 C137.1 C138.2 C139.1 C140.1 C141.2 C142.2 C143.2 C144.1 C145.1 C146.2 C147.2 C148.2 C149.1 C150.1 C151.1 C152.2 C153.2 C155.2 C156.2 C157.2 C158.1 C160.1 C161.2 C162.1 C163.2 C164.1 C165.2 C166.2 C167.1 C168.2 C169.1 C170.1 C171.2 C172.2 C173.1 C174.1 C175.2 C176.1 C177.1 C178.1 C179.1 C180.1 C182.1 C186.1 C187.1 C188.2 C189.1 C190.1 C194.2 C195.2 C196.1 C200.2 C201.2 C202.1 C203.1 C204.1 C205.2 C206.2 C207.2 C208.2 C209.2 C210.1 C211.1 C212.2 C213.2 C214.2 C215.1 C216.2 C217.2 C218.2 C219.2 C221.1 C222.2 C226.2 C227.1 C228.2 C229.2 C230.2 C232.2 C233.1 C234.2 C235.1 C236.1 C237.1 C238.2 C239.1 C240.1 C241.2 C242.1 C244.1 C245.2 C246.2 C247.1 C248.2 C250.2 C251.2 C252.2 C253.2 C254.2 C256.2 C257.2 C258.2 C260.2 C261.2 C262.2 C263.1 C265.1 C266.2 C268.1 C269.2 C270.2 C271.1 C273.1 C274.1 C275.1 C276.1 C277.2 C278.2 C279.1 C280.2 C281.1 C282.1 C283.1 C284.1 C292.1 C293.1 C296.1 C297.1 C298.1 C300.1 C301.1 C302.1 C303.1 C304.1 C305.1 C306.1 C307.2 C308.2 C309.1 C310.1 C311.2 C313.1 C315.2 C316.1 C317.2 C318.2 C319.1 C320.2 C321.1 C322.1 C327.1 C328.2 C329.1 C330.2 C331.2 C336.2 C337.1 C338.1 C339.1 C340.1 C341.1 C342.2 C343.1 C344.1 C345.1 C346.1 C347.1 C348.1 C349.1 C350.1 C351.1 C352.2 C353.2 C354.2 C355.2 C356.2 C357.2 C358.2 C359.1 C360.2 C361.2 C362.1 C363.2 C364.2 C365.2 C366.2 C367.2 C368.2 C369.2 C370.1 C371.1 C372.2 C373.2 C374.2 C375.2 C376.2 C377.2 C378.2 C379.2 C380.2 C381.1 C382.2 C383.2 C384.2 C385.2 C386.1 C387.1 C388.1 C389.1 C390.2 C391.1 C392.1 C393.1 C394.2 C396.2 C397.1 C398.1 C399.1 C400.2 C402.1 C403.2 C404.1 C405.1 C406.1 C407.1 C408.2 C409.1 C410.2 C411.2 C412.2 C414.1 C415.2 C416.2 C418.1 C419.1 C420.1 C422.1 C425.2 C426.2 C429.2 C430.1 C432.2 C433.2 C434.2 C435.2 C436.2 C438.1 C439.1 C440.2 C445.2 C446.2 C447.2 C448.2 CN1.1(GND#5) CN1.2(GND#6) CN1.3(GND#7) CN1.4(GND#8) CN1.A1(GND#1) CN1.A12(GND#2) CN1.B1(GND#3) CN1.B12(GND#4) CN2.3(VSS) CN2.6(VSS#2) CN2.12(GND#1) CN2.13(GND#2) CN3.3 CN3.6 CN3.9 CN3.12 CN3.15 CN3.18 CN3.21 CN3.24 CN3.41 CN3.42 CN4.9 CN4.10 CN4.11 CN4.12 CN5.1 CN5.3 CN5.9 CN5.15 CN5.21 CN5.27 CN5.33 CN5.39 CN5.45 CN5.51 CN5.57 CN5.71 CN5.73 CN5.75 CN5.76 CN5.77 CN6.2(D2_SHIELD) CN6.5(D1_SHIELD) CN6.8(D0_SHIELD) CN6.11(CLK_SHIELD) CN6.17(GND#1) CN6.20 CN6.21 CN6.22 CN6.23 CN7.2 CN7.3 CN7.4 CN8.4(GND) CN8.7(GND_DRAIN) CN8.10(SHIELD#2) CN8.11(SHIELD#1) CN8.12(SHIELD#4) CN8.13(SHIELD#3) CN9.1 CN9.7 CN9.18 CN9.33 CN9.39 CN9.45 CN9.51 CN9.57 CN9.63 CN9.69 CN9.75 CN9.76 CN9.77 CN10.4 CN10.5 CN10.6 CN11.4 CN11.7 CN11.10 CN11.11 CN11.12 CN12.8 CN12.9 CN12.10 CN12.14 CN12.17 CN12.20 CN12.21 CN12.22 CN12.23 CN12.24 CN13.2 CN14.28 CN14.29 CN14.30 CN15.4 CN15.9 CN15.10 CN16.1 CN16.4 CN16.7 CN16.17 CN16.18 CN16.19 CN16.20 CN17.12 CN17.13 CN17.16 CN17.17 CN17.20 CN17.21 CN17.35 CN17.36 CN18.1 CN18.5 CN18.6 CN19.5 CN19.6 D3.2 D4.1 D5.1 D6.1 D9.1 D10.1 D11.1 D12.1 D13.1 D14.1 D27.1 D28.1 D29.2 D30.2 ESD1.2(GND) ESD2.3(GND) ESD3.3(NC#1) ESD3.8(NC#2) ESD3.9(GND#1) ESD3.11(GND#2) ESD4.2(GND) ESD5.2(GND) ESD6.3(GND#1) ESD7.3(GND#1) HOLE1.1 HOLE2.1 HOLE2.2 HOLE2.3 HOLE2.4 HOLE2.5 HOLE2.6 HOLE2.7 HOLE2.8 HOLE2.9 HOLE3.1 HOLE4.1 HOLE5.1 HOLE5.2 HOLE5.3 HOLE5.4 HOLE5.5 HOLE5.6 HOLE5.7 HOLE5.8 HOLE5.9 HOLE7.1 HOLE8.1 HOLE8.2 HOLE8.3 HOLE8.4 HOLE8.5 HOLE8.6 HOLE8.7 HOLE8.8 HOLE8.9 HOLE9.1 HOLE11.1 HOLE11.2 HOLE11.3 HOLE11.4 HOLE11.5 HOLE11.6 HOLE11.7 HOLE11.8 HOLE11.9 HOLE12.1 HOLE12.2 HOLE12.3 HOLE12.4 HOLE12.5 HOLE12.6 HOLE12.7 HOLE12.8 HOLE12.9 HOLE13.1 HOLE13.2 HOLE13.3 HOLE13.4 HOLE13.5 HOLE13.6 HOLE13.7 HOLE13.8 HOLE13.9 HOLE14.1 HOLE14.2 HOLE14.3 HOLE14.4 HOLE14.5 HOLE14.6 HOLE14.7 HOLE14.8 HOLE14.9 HOLE15.1 HOLE15.2 HOLE15.3 HOLE15.4 HOLE15.5 HOLE15.6 HOLE15.7 HOLE15.8 HOLE15.9 J1.2 L5.2 PC1.2 PC2.2 PC3.1 PC5.1 PC6.2 PC7.1 PC8.1 PC9.2 PC10.1 PC13.2 PC14.2 PC16.1 PC17.1 PC18.1 PC19.1 PC20.2 PC21.2 PC22.2 PC23.2 PC24.2 PC25.2 PC26.2 PC27.2 PC28.2 PC29.2 PC30.2 PC31.2 PC32.2 PC33.2 PC35.2 PC36.2 PC37.1 PC38.1 PC39.2 PC40.2 PC41.2 PC42.2 PC43.1 PC44.1 PC45.2 PC46.1 PC47.2 PC48.1 PC49.1 PC51.1 PC52.2 PC53.1 PC55.1 PC56.2 PC57.2 PC58.1 PC59.2 PC61.1 PC62.1 PC63.2 PC64.2 PC65.2 PC66.1 PC67.1 PC68.2 PC69.2 PC70.1 PC71.1 PC72.2 PC73.2 PC74.2 PC76.2 PC77.1 PC78.1 PC80.2 PC81.2 PC82.2 PC85.2 PC89.2 PC92.2 PC93.2 PC94.2 PC95.2 PC96.2 PC97.2 PC99.2 PC100.2 PC101.2 PC102.2 PC103.2 PC104.2 PC105.2 PC106.2 PC107.2 PC108.2 PC109.2 PC110.2 PC111.2 PC112.2 PC113.2 PC114.2 PC115.2 PC116.2 PC117.2 PC118.2 PC119.2 PC120.2 PC121.2 PC122.2 PC123.2 PC124.2 PC125.2 PC126.2 PC127.1 PC128.2 PC129.2 PC130.2 PC131.2 PC132.2 PC133.2 PC134.2 PC135.2 PC136.2 PC138.1 PC139.2 PC140.2 PC141.2 PC142.2 PC143.2 PC144.2 PC145.1 PC146.1 PC147.2 PC148.2 PC149.2 PC150.2 PC151.2 PC152.2 PC153.2 PC154.2 PC155.2 PC156.2 PC157.2 PC158.2 PC159.2 PC160.2 PC161.2 PC162.2 PC163.1 PC165.2 PC166.2 PC167.2 PC168.2 PC169.2 PC170.2 PC171.2 PC172.2 PC173.2 PC174.2 PC175.2 PC176.2 PC177.2 PC178.2 PC179.2 PC180.2 PC181.2 PC182.2 PC183.2 PC184.2 PC185.2 PC186.2 PC187.2 PC188.2 PC189.2 PC191.2 PC192.2 PC193.2 PC194.2 PC195.2 PC196.2 PC197.2 PC198.2 PC199.2 PC200.2 PC201.2 PC202.2 PC203.2 PC204.2 PC205.2 PC206.2 PC208.2 PC209.2 PC210.2 PC211.2 PC212.2 PC213.2 PC214.2 PD2.2 PD5.2 PD6.2 PJ1.1 PJ1.2 PJ2.1 PJ2.2 PJ2.3 PJ2.7 PJ2.8 PJ5.1 PJ5.2 PJ5.9 PJ5.10 PQ1.1(S) PQ2.1(EMITTER) PQ3.1(S) PQ5.1(S) PQ7.1(S) PQ8.1(S) PQ9.1(S) PQ9.4(S) PQ10.1(S) PQ12.1(S1) PQ12.2(S2) PQ12.3(S3) PQ14.1(S1) PQ14.2(S2) PQ14.3(S3) PQ15.1(S) PQ16.6(NPN#C) PQ19.1(S1) PQ19.2(S2) PQ19.3(S3) PQ21.1(S1) PQ21.2(S2) PQ21.3(S3) PQ23.1(S) PQ24.1(EMITTER) PQ25.1(S) PR3.2 PR8.1 PR11.2 PR18.2 PR20.2 PR21.2 PR25.1 PR31.2 PR37.2 PR38.2 PR47.2 PR61.1 PR68.1 PR77.1 PR96.2 PR98.2 PR128.2 PR143.2 PR153.2 PR155.2 PR162.2 PR167.2 PR184.2 PR185.2 PR188.2 PR192.2 PR198.2 PR199.2 PR200.1 PR211.2 PR212.2 PU1.4(AGND) PU1.5(PGND) PU1.11(EPAD#1) PU1.12(EPAD#2) PU1.13(EPAD#3) PU1.14(EPAD#4) PU1.15(EPAD#5) PU1.16(EPAD#6) PU2.14(GND#1) PU2.21(GND#2) PU2.22(GND#3) PU2.23(GND#4) PU2.24(GND#5) PU2.25(GND#6) PU3.4(GND#1) PU3.9(GND#2) PU4.4(GND#1) PU4.9(GND#2) PU5.7(GND#1) PU5.8(GND#2) PU5.18(GND#3) PU5.21(GND#4) PU6.41(EP) PU7.11(GND#1) PU7.15(GND#2) PU8.11(GND) PU9.2(GND) PU9.4(HYST) PU10.2(GND) PU11.7(GND#1) PU11.8(GND#2) PU11.18(GND#3) PU11.21(GND#4) PU12.2(GND) PU13.11(GND#1) PU13.15(GND#2) PU14.8(GND#1) PU14.9(GND#2) PU15.1(VTTGND) PU15.14(PGND) PU15.21(PAD) Q1.1(S) Q2.1(EMITTER) Q3.1(S) Q3.4(S) Q4.1(S) Q4.4(S) Q6.1(S) Q8.1(S) Q9.1(S) Q11.1(S) Q11.4(S) Q12.1(S) Q13.1(S) Q14.3(GND) Q17.1(S) Q19.1(S) Q19.4(S) Q20.1(S) Q20.4(S) Q23.1(EMITTER) Q24.1(S) Q24.4(S) Q25.1(S) Q25.4(S) Q26.1(S) Q26.4(S) Q27.1(S) Q27.4(S) Q28.1(S) Q28.4(S) Q30.1(S) Q31.1(S) Q33.1(S) Q33.4(S) Q35.1(S) Q35.4(S) Q36.1(S) Q36.4(S) R2.2 R8.2 R29.1 R30.2 R31.2 R32.1 R33.2 R34.1 R35.1 R36.1 R39.1 R40.2 R41.1 R42.1 R43.1 R44.2 R47.1 R54.1 R55.1 R57.1 R58.1 R59.1 R61.2 R64.2 R70.1 R72.2 R73.1 R75.2 R83.2 R87.2 R89.2 R91.2 R97.2 R101.2 R102.2 R109.2 R111.2 R117.2 R146.1 R147.1 R149.1 R150.1 R155.1 R159.1 R162.1 R164.1 R169.2 R172.2 R173.1 R207.2 R210.2 R215.2 R216.2 R217.2 R219.2 R220.2 R221.1 R225.2 R227.1 R228.2 R233.1 R235.1 R239.1 R241.2 R242.2 R254.2 R262.1 R265.2 R278.2 R281.1 R282.1 R283.1 R284.1 R285.1 R286.1 R287.1 R288.1 R313.1 R322.2 R334.1 R335.2 R338.1 R339.1 R340.1 R341.1 R342.1 R343.2 R344.2 R345.2 R346.1 R347.1 R348.1 R349.1 R350.1 R355.1 R357.2 R364.1 R367.2 R382.2 R400.2 R411.1 R412.1 R413.1 R414.1 R444.2 R449.2 R458.2 R460.1 R469.2 R470.1 R471.1 R473.1 R479.1 R480.2 R481.2 R485.1 R486.1 R491.1 R493.2 SPAD1.1 SPAD2.1 SPAD3.1 SPAD4.1 SPAD5.1 SPAD6.1 SW1.1 SW1.2 SW1.5 SW1.6 SW3.1 SW3.2 SW3.5 SW3.6 U1.4(VSS) U2.AA4(VSSQ_4) U2.AA6(VSSQ_1) U2.K4(VSSQ_3) U2.M7(VSS_3) U2.P5(VSS_4) U2.R10(VSS_1) U2.U8(VSS_2) U2.Y2(VSSQ_5) U2.Y5(VSSQ_2) U3.12(GND#1) U3.21(PWPD) U4.2(GND) U5.2(GND) U6.17(OE_N) U6.33(GND#1) U6.34(GND#2) U6.35(GND#3) U6.36(GND#4) U6.37(GND#5) U7.2(GND) U8.A9(VSS#A9) U8.B1(VSSQ#B1) U8.B3(VSS#B3) U8.B9(VSSQ#B9) U8.D1(VSSQ#D1) U8.D3(DMU) U8.D8(VSSQ#D8) U8.E1(VSS#E1) U8.E2(VSSQ#E2) U8.E7(DML) U8.E8(VSSQ#E8) U8.F9(VSSQ#F9) U8.G1(VSSQ#G1) U8.G8(VSS#G8) U8.G9(VSSQ#G9) U8.J2(VSS#J2) U8.J8(VSS#J8) U8.M1(VSS#M1) U8.M9(VSS#M9) U8.P1(VSS#P1) U8.P9(VSS#P9) U8.T1(VSS#T1) U8.T9(VSS#T9) U9.A9(VSS#A9) U9.B1(VSSQ#B1) U9.B3(VSS#B3) U9.B9(VSSQ#B9) U9.D1(VSSQ#D1) U9.D3(DMU) U9.D8(VSSQ#D8) U9.E1(VSS#E1) U9.E2(VSSQ#E2) U9.E7(DML) U9.E8(VSSQ#E8) U9.F9(VSSQ#F9) U9.G1(VSSQ#G1) U9.G8(VSS#G8) U9.G9(VSSQ#G9) U9.J2(VSS#J2) U9.J8(VSS#J8) U9.M1(VSS#M1) U9.M9(VSS#M9) U9.P1(VSS#P1) U9.P9(VSS#P9) U9.T1(VSS#T1) U9.T9(VSS#T9) U10.A9(VSS#A9) U10.B1(VSSQ#B1) U10.B3(VSS#B3) U10.B9(VSSQ#B9) U10.D1(VSSQ#D1) U10.D3(DMU) U10.D8(VSSQ#D8) U10.E1(VSS#E1) U10.E2(VSSQ#E2) U10.E7(DML) U10.E8(VSSQ#E8) U10.F9(VSSQ#F9) U10.G1(VSSQ#G1) U10.G8(VSS#G8) U10.G9(VSSQ#G9) U10.J2(VSS#J2) U10.J8(VSS#J8) U10.M1(VSS#M1) U10.M9(VSS#M9) U10.P1(VSS#P1) U10.P9(VSS#P9) U10.T1(VSS#T1) U10.T9(VSS#T9) U11.A9(VSS#A9) U11.B1(VSSQ#B1) U11.B3(VSS#B3) U11.B9(VSSQ#B9) U11.D1(VSSQ#D1) U11.D3(DMU) U11.D8(VSSQ#D8) U11.E1(VSS#E1) U11.E2(VSSQ#E2) U11.E7(DML) U11.E8(VSSQ#E8) U11.F9(VSSQ#F9) U11.G1(VSSQ#G1) U11.G8(VSS#G8) U11.G9(VSSQ#G9) U11.J2(VSS#J2) U11.J8(VSS#J8) U11.M1(VSS#M1) U11.M9(VSS#M9) U11.P1(VSS#P1) U11.P9(VSS#P9) U11.T1(VSS#T1) U11.T9(VSS#T9) U12.3(GND#1) U12.13(GND#2) U12.18(GND#3) U12.21(PPAD) U12.22(GND#4) U12.23(GND#5) U12.24(GND#6) U12.25(GND#7) U12.26(GND#8) U13.34(ENSWREG_H) U13.49(E_PAD) U14.9(GND1) U14.16(GND2) U14.23(GND3) U14.32(GND4) U14.33(EPAD) U15.4(DC DET) U15.49(DGND) U16.1(VSS#1) U16.27(VSS#2) U16.49(VSS#3) U16.91(VSS#4) U16.104(VSS#5) U17.5(GND#1) U17.7(SDO/SA0) U17.10(RES) U17.12(GND#2) U17.13(ADC3) U17.15(ADC2) U17.16(ADC1) U18.2(GND) U19.2(GND) U20.25(GND) U21.A5(VSS_12) U21.A9(VSS_16) U21.A12(VSS_2) U21.A16(VSS_3) U21.A20(VSS_4) U21.A24(VSS_5) U21.A28(VSS_6) U21.A32(VSS_7) U21.A36(VSS_8) U21.A40(VSS_9) U21.A44(VSS_10) U21.A48(VSS_11) U21.A52(VSS_13) U21.A56(VSS_14) U21.A62(VSS_15) U21.AA1(VSS_17) U21.AA2(VSS_18) U21.AA27(VSS_19) U21.AA34(VSS_20) U21.AA41(VSS_21) U21.AA63(VSS_22) U21.AB5(VSS_27) U21.AB9(VSS_31) U21.AB10(VSS_23) U21.AB12(VSS_24) U21.AB16(VSS_25) U21.AB48(VSS_26) U21.AB52(VSS_28) U21.AB57(VSS_29) U21.AB59(VSS_30) U21.AC16(USB2_VBUS_SNS) U21.AC18(VSS_32) U21.AC27(VSS_33) U21.AC34(VSS_34) U21.AC39(VSS_35) U21.AE1(VSS_36) U21.AE2(VSS_43) U21.AE4(VSS_48) U21.AE5(VSS_52) U21.AE7(VSS_61) U21.AE8(VSS_62) U21.AE10(VSS_37) U21.AE11(VSS_38) U21.AE13(VSS_39) U21.AE14(VSS_40) U21.AE16(VSS_41) U21.AE17(VSS_42) U21.AE23(VSS_44) U21.AE27(VSS_45) U21.AE34(VSS_46) U21.AE39(VSS_47) U21.AE41(VSS_49) U21.AE47(VSS_50) U21.AE48(VSS_51) U21.AE50(VSS_53) U21.AE51(VSS_54) U21.AE53(VSS_55) U21.AE54(VSS_56) U21.AE56(VSS_57) U21.AE57(VSS_58) U21.AE59(VSS_59) U21.AE63(VSS_60) U21.AG13(VSS_63) U21.AG18(VSS_64) U21.AG23(VSS_65) U21.AG27(VSS_66) U21.AG34(VSS_67) U21.AG37(VSS_68) U21.AG39(VSS_69) U21.AG41(VSS_70) U21.AG42(VSS_71) U21.AG44(VSS_72) U21.AG46(VSS_73) U21.AH5(VSS_77) U21.AH6(VSS_84) U21.AH7(VSS_85) U21.AH15(VSS_74) U21.AH16(VSS_75) U21.AH48(VSS_76) U21.AH52(VSS_78) U21.AH54(VSS_79) U21.AH55(VSS_80) U21.AH57(VSS_81) U21.AH58(VSS_82) U21.AH59(VSS_83) U21.AJ1(VSS_86) U21.AJ2(VSS_88) U21.AJ18(VSS_87) U21.AJ23(VSS_89) U21.AJ27(VSS_90) U21.AJ34(VSS_91) U21.AJ36(VSS_92) U21.AJ63(VSS_93) U21.AK5(VSS_101) U21.AK9(VSS_104) U21.AK10(VSS_94) U21.AK12(VSS_95) U21.AK18(VSS_96) U21.AK23(VSS_97) U21.AK27(VSS_98) U21.AK36(VSS_99) U21.AK48(VSS_100) U21.AK52(VSS_102) U21.AK59(VSS_103) U21.AM18(VSS_105) U21.AM22(VSS_106) U21.AM27(VSS_107) U21.AM34(VSS_108) U21.AM36(VSS_109) U21.AM39(VSS_110) U21.AM46(VSS_111) U21.AN1(VSS_112) U21.AN2(VSS_119) U21.AN5(VSS_130) U21.AN7(VSS_139) U21.AN8(VSS_140) U21.AN10(VSS_113) U21.AN11(VSS_114) U21.AN13(VSS_115) U21.AN14(VSS_116) U21.AN16(VSS_117) U21.AN17(VSS_118) U21.AN25(VSS_120) U21.AN27(VSS_121) U21.AN28(VSS_122) U21.AN30(VSS_123) U21.AN34(VSS_124) U21.AN36(VSS_125) U21.AN37(VSS_126) U21.AN39(VSS_127) U21.AN47(VSS_128) U21.AN48(VSS_129) U21.AN50(VSS_131) U21.AN51(VSS_132) U21.AN53(VSS_133) U21.AN54(VSS_134) U21.AN56(VSS_135) U21.AN57(VSS_136) U21.AN59(VSS_137) U21.AN63(VSS_138) U21.AP9(VSS_142) U21.AP55(VSS_141) U21.AR19(VSS_143) U21.AR32(VSS_144) U21.AR45(VSS_145) U21.AT2(VSS_149) U21.AT3(VSS_152) U21.AT7(VSS_161) U21.AT12(VSS_146) U21.AT16(VSS_147) U21.AT19(VSS_148) U21.AT25(VSS_150) U21.AT29(VSS_151) U21.AT35(VSS_153) U21.AT39(VSS_154) U21.AT45(VSS_155) U21.AT48(VSS_156) U21.AT52(VSS_157) U21.AT57(VSS_158) U21.AT61(VSS_159) U21.AT62(VSS_160) U21.AU32(VSS_162) U21.AV2(VSS_164) U21.AV3(VSS_168) U21.AV9(VSS_177) U21.AV19(VSS_163) U21.AV21(VSS_165) U21.AV23(VSS_166) U21.AV29(VSS_167) U21.AV32(VSS_169) U21.AV35(VSS_170) U21.AV41(VSS_171) U21.AV43(VSS_172) U21.AV45(VSS_173) U21.AV55(VSS_174) U21.AV61(VSS_175) U21.AV62(VSS_176) U21.AW14(VSS_178) U21.AW30(VSS_179) U21.AW34(VSS_180) U21.AW50(VSS_181) U21.AY6(VSS_186) U21.AY10(VSS_182) U21.AY32(VSS_183) U21.AY54(VSS_184) U21.AY58(VSS_185) U21.B2(VSS_187) U21.B3(VSS_188) U21.B9(VSS_191) U21.B62(VSS_189) U21.B63(VSS_190) U21.BA1(VSS_192) U21.BA2(VSS_196) U21.BA12(VSS_193) U21.BA16(VSS_194) U21.BA17(VSS_195) U21.BA21(VSS_197) U21.BA25(VSS_198) U21.BA27(VSS_199) U21.BA29(VSS_200) U21.BA32(VSS_201) U21.BA35(VSS_202) U21.BA37(VSS_203) U21.BA39(VSS_204) U21.BA43(VSS_205) U21.BA47(VSS_206) U21.BA48(VSS_207) U21.BA52(VSS_208) U21.BA62(VSS_209) U21.BA63(VSS_210) U21.BB3(VSS_213) U21.BB19(VSS_211) U21.BB25(VSS_212) U21.BB39(VSS_214) U21.BB45(VSS_215) U21.BB61(VSS_216) U21.BC32(VSS_217) U21.BD3(VSS_218) U21.BD8(VSS_222) U21.BD32(VSS_219) U21.BD56(VSS_220) U21.BD61(VSS_221) U21.BE1(VSS_223) U21.BE10(VSS_224) U21.BE12(VSS_225) U21.BE16(VSS_226) U21.BE17(VSS_227) U21.BE21(VSS_228) U21.BE27(VSS_229) U21.BE29(VSS_230) U21.BE35(VSS_231) U21.BE37(VSS_232) U21.BE43(VSS_233) U21.BE47(VSS_234) U21.BE48(VSS_235) U21.BE52(VSS_236) U21.BE54(VSS_237) U21.BE63(VSS_238) U21.BF3(VSS_239) U21.BF32(VSS_240) U21.BF61(VSS_241) U21.BG19(VSS_242) U21.BG23(VSS_243) U21.BG29(VSS_244) U21.BG32(VSS_245) U21.BG35(VSS_246) U21.BG41(VSS_247) U21.BG45(VSS_248) U21.BH1(VSS_249) U21.BH2(VSS_250) U21.BH21(VSS_251) U21.BH25(VSS_252) U21.BH39(VSS_253) U21.BH43(VSS_254) U21.BH62(VSS_255) U21.BH63(VSS_256) U21.BJ4(VSS_263) U21.BJ8(VSS_269) U21.BJ10(VSS_257) U21.BJ14(VSS_258) U21.BJ18(VSS_259) U21.BJ28(VSS_260) U21.BJ32(VSS_261) U21.BJ36(VSS_262) U21.BJ46(VSS_264) U21.BJ50(VSS_265) U21.BJ54(VSS_266) U21.BJ56(VSS_267) U21.BJ60(VSS_268) U21.C12(VSS_270) U21.C16(VSS_271) U21.C28(VSS_272) U21.C32(VSS_273) U21.C40(VSS_274) U21.C48(VSS_275) U21.D6(VSS_278) U21.D32(VSS_276) U21.D58(VSS_277) U21.E4(VSS_283) U21.E12(VSS_279) U21.E14(VSS_280) U21.E19(VSS_281) U21.E27(VSS_282) U21.E54(VSS_284) U21.F3(VSS_287) U21.F10(VSS_285) U21.F21(VSS_286) U21.F32(VSS_288) U21.F37(VSS_289) U21.F43(VSS_290) U21.F45(VSS_291) U21.F50(VSS_292) U21.F56(VSS_293) U21.F59(VSS_294) U21.F63(VSS_295) U21.G1(VSS_296) U21.G32(VSS_297) U21.H3(VSS_301) U21.H7(VSS_305) U21.H17(VSS_298) U21.H23(VSS_299) U21.H29(VSS_300) U21.H37(VSS_302) U21.H47(VSS_303) U21.H61(VSS_304) U21.J12(VSS_306) U21.J14(VSS_307) U21.J19(VSS_308) U21.J27(VSS_309) U21.J30(VSS_310) U21.J32(VSS_311) U21.J35(VSS_312) U21.J37(VSS_313) U21.J48(VSS_314) U21.J63(VSS_315) U21.K5(VSS_317) U21.K6(VSS_320) U21.K32(VSS_316) U21.K54(VSS_318) U21.K57(VSS_319) U21.L21(VSS_321) U21.L27(VSS_322) U21.L29(VSS_323) U21.L35(VSS_324) U21.L43(VSS_325) U21.L45(VSS_326) U21.L50(VSS_327) U21.M3(VSS_331) U21.M9(VSS_335) U21.M14(VSS_328) U21.M21(VSS_329) U21.M27(VSS_330) U21.M32(VSS_332) U21.M50(VSS_333) U21.M59(VSS_334) U21.N1(VSS_336) U21.N32(VSS_337) U21.N63(VSS_338) U21.P5(VSS_346) U21.P9(VSS_349) U21.P13(VSS_339) U21.P19(VSS_340) U21.P35(VSS_341) U21.P37(VSS_342) U21.P41(VSS_343) U21.P43(VSS_344) U21.P45(VSS_345) U21.P55(VSS_347) U21.P59(VSS_348) U21.R23(VSS_350) U21.R29(VSS_1) U21.R32(VSS_351) U21.T49(VSS_352) U21.U1(VSS_353) U21.U2(VSS_361) U21.U5(VSS_364) U21.U7(VSS_374) U21.U8(VSS_375) U21.U10(VSS_354) U21.U11(VSS_355) U21.U13(VSS_356) U21.U14(VSS_357) U21.U16(VSS_358) U21.U17(VSS_359) U21.U18(VSS_360) U21.U27(VSS_362) U21.U34(VSS_363) U21.U50(VSS_365) U21.U51(VSS_366) U21.U53(VSS_367) U21.U54(VSS_368) U21.U56(VSS_369) U21.U57(VSS_370) U21.U59(VSS_371) U21.U62(VSS_372) U21.U63(VSS_373) U21.V20(VSS_376) U21.V27(VSS_377) U21.V34(VSS_378) U21.V42(VSS_379) U21.Y5(VSS_388) U21.Y6(VSS_394) U21.Y7(VSS_395) U21.Y12(VSS_380) U21.Y16(VSS_381) U21.Y22(VSS_382) U21.Y27(VSS_383) U21.Y34(VSS_384) U21.Y42(VSS_385) U21.Y46(VSS_386) U21.Y48(VSS_387) U21.Y52(VSS_389) U21.Y54(VSS_390) U21.Y55(VSS_391) U21.Y57(VSS_392) U21.Y59(VSS_393) U22.2(GND) U23.2(GND) U24.A9(VSS#A9) U24.B1(VSSQ#B1) U24.B3(VSS#B3) U24.B9(VSSQ#B9) U24.D1(VSSQ#D1) U24.D3(DMU) U24.D8(VSSQ#D8) U24.E1(VSS#E1) U24.E2(VSSQ#E2) U24.E7(DML) U24.E8(VSSQ#E8) U24.F9(VSSQ#F9) U24.G1(VSSQ#G1) U24.G8(VSS#G8) U24.G9(VSSQ#G9) U24.J2(VSS#J2) U24.J8(VSS#J8) U24.M1(VSS#M1) U24.M9(VSS#M9) U24.P1(VSS#P1) U24.P9(VSS#P9) U24.T1(VSS#T1) U24.T9(VSS#T9) U25.A9(VSS#A9) U25.B1(VSSQ#B1) U25.B3(VSS#B3) U25.B9(VSSQ#B9) U25.D1(VSSQ#D1) U25.D3(DMU) U25.D8(VSSQ#D8) U25.E1(VSS#E1) U25.E2(VSSQ#E2) U25.E7(DML) U25.E8(VSSQ#E8) U25.F9(VSSQ#F9) U25.G1(VSSQ#G1) U25.G8(VSS#G8) U25.G9(VSSQ#G9) U25.J2(VSS#J2) U25.J8(VSS#J8) U25.M1(VSS#M1) U25.M9(VSS#M9) U25.P1(VSS#P1) U25.P9(VSS#P9) U25.T1(VSS#T1) U25.T9(VSS#T9) U26.A9(VSS#A9) U26.B1(VSSQ#B1) U26.B3(VSS#B3) U26.B9(VSSQ#B9) U26.D1(VSSQ#D1) U26.D3(DMU) U26.D8(VSSQ#D8) U26.E1(VSS#E1) U26.E2(VSSQ#E2) U26.E7(DML) U26.E8(VSSQ#E8) U26.F9(VSSQ#F9) U26.G1(VSSQ#G1) U26.G8(VSS#G8) U26.G9(VSSQ#G9) U26.J2(VSS#J2) U26.J8(VSS#J8) U26.M1(VSS#M1) U26.M9(VSS#M9) U26.P1(VSS#P1) U26.P9(VSS#P9) U26.T1(VSS#T1) U26.T9(VSS#T9) U27.A9(VSS#A9) U27.B1(VSSQ#B1) U27.B3(VSS#B3) U27.B9(VSSQ#B9) U27.D1(VSSQ#D1) U27.D3(DMU) U27.D8(VSSQ#D8) U27.E1(VSS#E1) U27.E2(VSSQ#E2) U27.E7(DML) U27.E8(VSSQ#E8) U27.F9(VSSQ#F9) U27.G1(VSSQ#G1) U27.G8(VSS#G8) U27.G9(VSSQ#G9) U27.J2(VSS#J2) U27.J8(VSS#J8) U27.M1(VSS#M1) U27.M9(VSS#M9) U27.P1(VSS#P1) U27.P9(VSS#P9) U27.T1(VSS#T1) U27.T9(VSS#T9) U28.4(GND) U29.2(GND) U30.2(GND) U31.4(GND) U32.21(GNDA#1) U32.31(GNDA#2) U32.42(TEST_EN) U32.49(EPAD) Y2.2 Y2.4 Y3.2 Y3.4 Y4.2 Y4.4
PGND: C413.1 C421.2 R241.1 U32.47(PGND)
VCC1.2O: L10.2 U32.48(LXI)
VCC_XD: C262.1 C263.2 C448.1 CN2.4(VDD) U13.13(CARD_3V3)
VCCDSW: TP23.1 U16.83(EGCS#/GPE2)
VCCGI_SENSE: PR124.1 U21.R41(VCC_VCGI_SENSE_P)
VCCGISS_SENSE: PR119.1 U21.R43(VCC_VCGI_SENSE_N)
VCCRTC_2: CN7.1 CN13.1 Q34.1(EMITTER) R463.1
VCCRTC_3: Q34.3(COLLECTOR) R475.2
VCCRTC_4: R474.2 R475.1
VDD10: C177.2 C189.2 C210.2 C386.2 C403.1 C407.2 R174.2 U13.3(AVDD10#1) U13.8(AVDD10#2) U13.20(EVDD10) U13.33(DVDD10) U13.46(AVDD10)
1P35V_BOOT: PR195.2 PU15.18(BOOT)
1P35V_CS: PR199.1 PU15.13(CS)
1P35V_FB: PR191.2 PR192.1 PU15.6(FB)
1P35V_LGATE: PQ19.4(G) PU15.15(LGATE)
1P35V_PGOOD: PR196.2 PU15.10(PGOOD)
1P35V_PHASE: PC207.1 PL9.1 PQ18.1(S1) PQ18.2(S2) PQ18.3(S3) PQ19.5(D) PR52.1 PU15.16(PHASE)
1P35V_S3: PC41.1 PR53.2 PR193.2 PU15.7(S3)
1P35V_S5: PC47.1 PR53.1 PR59.2 PU15.8(S5)
1P35V_TON: PR194.2 PU15.9(TON)
1P35V_UGATE: PQ18.4(G) PU15.17(UGATE)
1P35V_VDD: PC210.1 PR64.1 PU15.12(VDD)
1P35V_VDDQ: PR190.1 PR191.1 PU15.5(VDDQ)
1P35V_VID: PR65.1 PR198.1 PU15.11(VID)
2ND_MBCLK: R177.1 U16.115(SMCLK1/GPC1) U23.1(SMBCLK)
2ND_MBDATA: R176.1 U16.116(SMDAT1/GPC2) U23.5(SMBDATA)
680_LDO: C396.1 PR15.2 R450.1 U30.1(VIN)
8068EN_1.05V: PC140.1 PR142.2 PU8.5(EN)
8068FB_1.05V: PC137.2 PR141.2 PR143.1 PU8.6(FB)
8068FB_1.05V_S: PC137.1 PR141.1 PR146.2
8068LX_1.05V: PL5.1 PR148.1 PU8.1(NC#1) PU8.2(SW#1) PU8.3(SW#2)
8068NC_1.05V: PC141.1 PU8.7(NC#2)
8068PG_1.05V: PR145.1 PU8.4(POK)
8068SVIN_1.05V: PC142.1 PR147.2 PU8.8(VCC)
24707_LX: PC54.1 PL10.1 PQ20.1(S1) PQ20.2(S2) PQ20.3(S3) PQ21.5(D) PR69.1 PU2.19(PHASE)
24737_ACDET: PR67.2 PR68.2 PU2.6(ACDET)
24737_ACN: PC45.1 PC50.2 PR45.1 PU2.1(ACN)
24737_ACP: PC46.2 PC50.1 PR46.1 PU2.2(ACP)
24737_BM#: PQ10.2(G) PR81.1 PU2.11(B\M\)
24737_BST: PR72.1 PU2.17(BTST)
24737_CMPIN: PR54.2 PR61.2 PR66.1 PU2.4(CMPIN)
24737_CMPOUT: PQ8.2(G) PR55.2 PR62.1 PR66.2 PU2.3(CMPOUT)
24737_DH: PQ20.4(G) PU2.18(HIDRV)
24737_DL: PQ21.4(G) PU2.15(LODRV)
24737_ILIM: PC58.2 PR80.1 PR200.2 PR201.2 PU2.10(ILIM)
24737_REGN: PC59.1 PD7.2(ANODE) PU2.16(REGN)
24737_SRN: PC60.1 PC62.2 PR82.2 PR203.1
24737_SRP: PC60.2 PC61.2 PR83.2 PR202.1
24737_VCC: PC51.2 PR58.2 PU2.20(VCC)
25810_AUO#: R76.2 U3.17(A\U\D\I\O\)
25810_CC1: CN1.A5(CC1) ESD1.3 U3.11(CC1)
25810_CC2: CN1.B5(CC2) ESD1.4 U3.13(CC2)
25810_DBG#: R65.2 U3.16(D\E\B\U\G\)
25810_FAULT#: R68.2 R69.2 U3.1(F\A\U\L\T\)
25810_LD_DET#: R80.2 U3.20(L\D\_\D\E\T\)
25810_POL#: R77.2 U3.18(P\O\L\)
25810_REF: R48.2 U3.10(REF)
25810_REF_RTN: R48.1 U3.9(REF_RTN)
25810_UFP#: Q6.2(G) R78.2 R79.2 U3.19(U\F\P\)
25810_UFP#_G1: Q6.3(D) Q8.2(G) R96.2
25810_UFP#_G2: Q7.4(G) Q8.3(D) R94.2
61087COMP: PR10.2 PU1.1(COMP)
61087EN: PC7.2 PR7.2 PR28.2 PU1.3(EN)
61087FB: PR8.2 PR9.1 PU1.2(FB)
61087FREQ: PR25.2 PR29.1 PU1.9(FREQ)
61087SS: PC16.2 PU1.10(SS)
61087SW: PD1.2(ANODE) PL1.2 PU1.6(SW#1) PU1.7(SW#2)
+601_VCC: C182.2 C211.2 C381.2 C382.1 C383.1 R170.1 R171.1 R218.1 R416.2 R447.1 R451.1 R452.1 R453.1 U12.10(VCC#1) U12.20(VCC#2)
+AZA_VDD: C228.1 C229.1 C230.1 R232.1 R238.1 U15.1(DVDD) U15.36(CPVDD)
+SMDDR_VREF_CA_A: C139.2 C141.1 C146.1 R144.1 R146.2 U8.M8(VREFCA) U9.M8(VREFCA) U24.M8(VREFCA) U25.M8(VREFCA)
+SMDDR_VREF_CA_B: C163.1 C165.1 C167.2 R164.2 R166.1 U10.M8(VREFCA) U11.M8(VREFCA) U26.M8(VREFCA) U27.M8(VREFCA)
+SMDDR_VREF_DQ_A: C140.2 C142.1 C147.1 R145.1 R147.2 U8.H1(VREFDQ) U9.H1(VREFDQ) U24.H1(VREFDQ) U25.H1(VREFDQ)
+SMDDR_VREF_DQ_B: C149.2 C152.1 C156.1 R148.1 R150.2 U10.H1(VREFDQ) U11.H1(VREFDQ) U26.H1(VREFDQ) U27.H1(VREFDQ)
+TPVDD: C269.1 C270.1 CN15.1 ESD4.5(VDD) R263.2
+TYPEC_VBUS: C75.2 C340.2 C341.2 C342.1 C343.2 C344.2 C347.2 C349.2 C350.2 CN1.A4(VBUS#1) CN1.A9(VBUS#2) CN1.B4(VBUS#3) CN1.B9(VBUS#4) D3.1 Q7.1(S1) Q7.2(S2) Q7.3(S3) R94.1 R97.1
+TYPEC_VBUS_C: C42.1 C43.1 C54.2 Q7.5(D) U3.14(OUT#1) U3.15(OUT#2)
+VNN: C64.2 C65.2 C73.1 C76.1 C78.1 C85.2 C87.2 C90.1 C93.1 C292.2 C293.2 C297.2 C298.2 C301.2 C302.2 C303.2 C304.2 C305.2 PC23.1 PC26.1 PC93.1 PC97.1 PC101.1 PC104.1 PC106.1 PC110.1 PL2.2 PR94.2 PR95.1 U21.AJ37(VNN_SVID_1) U21.AJ39(VNN_SVID_2) U21.AJ41(VNN_SVID_3) U21.AJ42(VNN_SVID_4) U21.AJ46(VNN_SVID_5) U21.AK37(VNN_SVID_6) U21.AK39(VNN_SVID_7) U21.AK41(VNN_SVID_8) U21.AK42(VNN_SVID_9) U21.AK44(VNN_SVID_10) U21.AK46(VNN_SVID_11) U21.AM23(VCCIOA_1) U21.AM25(VCCIOA_2) U21.AM41(VCCIOA_3) U21.AM42(VCCIOA_4) U21.AM44(VNN_SVID_12)
+WL_VDD: C172.1 C173.2 C174.2 C236.2 C240.2 CN9.2 CN9.4 CN9.72 CN9.74 R163.1 R483.1 R489.2 U29.6(VCCB)
AC_PROTECT: PR55.1 U16.95(CTX1/SOUT1/GPH2/SMDAT3/ID2)
ACCEL_INT1: C242.2 D7.1(CATHODE) Q19.5(G)
ACCEL_INT1_R: D7.2(ANODE) U17.11(INT1)
ACCEL_INT2: CN12.13 D8.1(CATHODE) R242.1
ACCEL_INT2_R: D8.2(ANODE) U17.9(INT2)
ACCEL_INTA: Q19.6(D) R321.2 U21.B31(GPIO_6)
ACIN: PQ9.3(D) PR63.1 U16.72(ADC6/DSR1#/GPI6(3))
ACPRESENT: R85.1 R88.2 U21.AK49(PMU_AC_PRESENT)
ADOGND: C220.2 C223.1 C243.1 C249.1 C255.2 C259.2 C260.1 C401.2 C417.1 C428.2 C436.1 C441.1 C442.1 C443.2 CN17.23 CN17.30 CN17.32 CN17.34 R227.2 R235.2 R239.2 R251.1 R460.2 R473.2 R479.2 U15.25(AVSS1) U15.38(AVSS2)
ALERT#: TP39.1 U23.3(ALERT#)
AMP_MUTE#: D22.1(CATHODE) U16.108(RXD/SIN0/GPB0)
ASM_XIN: C395.2 U32.25(XI) Y4.1
ASM_XOUT: C395.1 U32.26(XO) Y4.3
AZ_CODEC_BITCLK: C247.2 R98.1 U15.6(BCLK)
AZ_CODEC_RST#: Q32.1(S) R52.1 U15.11(RESETB)
AZ_CODEC_SDIN0: R249.1 U21.AK51(ISH_GPIO_2)
AZ_CODEC_SDOUT: C245.1 R95.1 U15.5(SDATA-OUT)
AZ_CODEC_SYNC: R399.1 U15.10(SYNC)
AZ_SDIN0_R: R249.2 U15.8(SDATA-IN)
BAT-V: PC43.2 PC44.2 PC200.1 PC201.1 PC204.1 PC213.1 PC214.1 PJ5.7 PJ5.8 PQ17.5(D) PR78.2 PR82.1
BATLED0#: CN17.10 U16.29(PWM3/GPA3)
BATLED1#: CN17.11 U16.25(PWM1/GPA1)
BEEP_1: C264.2 C268.2 R255.1 R262.2
BI#: PJ5.6 PR77.2 SW2.1 SW2.2
BI_GATE: C384.1 Q31.2(G) Q33.5(G) R446.1 SW1.3 SW1.4
BL#: Q3.2(G) Q3.3(D) R11.1
BL_ON: CN3.26 D1.2(ANODE) Q2.3(COLLECTOR) Q3.6(D) R7.1
BOARD_ID0: R316.1 R339.2 U21.A38(GPIO_0)
BOARD_ID1: R320.1 R341.2 U21.B33(GPIO_1)
BOARD_ID2: R315.1 R348.2 U21.C39(GPIO_2)
BOARD_ID3: R314.1 R347.2 U21.B39(GPIO_3)
BOARD_ID4: R319.1 R349.2 U21.B35(GPIO_4)
BOARD_ID5: R309.1 R342.2 U21.A34(GPIO_5)
BOARD_ID6: R288.2 R296.1 U21.H39(GPIO_7)
BOARD_ID7: R282.2 R290.1 U21.A30(GPIO_9)
BOARD_ID8: R491.2 R492.1 U21.B29(GPIO_8)
BT_EN: CN9.54 U16.82(EGAD/GPE1)
CCD+DMIC_PWR: C281.2 C282.2 CN3.32 CN3.33 R276.2
CLK_LAN_REQ#: Q15.6(D) R226.2 U13.29(CLKREQB)
CLK_PCI_EC: R379.2 R467.2 U16.13(LPCCLK/GPM4(3))
CLK_PCI_LPC: CN9.71 R380.2
CLK_PCIE_LAN_REQ#: Q15.1(S) R397.2 R485.2 U21.AH61(PCIE_CLKREQ2_N)
CLK_PCIE_LANN: U13.24(REFCLK_N) U21.B8(PCIE_CLKOUT2N)
CLK_PCIE_LANP: U13.23(REFCLK_P) U21.A7(PCIE_CLKOUT2P)
CLK_PCIE_SSD_REQ#: Q36.6(D) R398.2 U4.3(A) U21.AK62(PCIE_CLKREQ0_N)
CLK_PCIE_SSDN: CN5.53 U21.B11(PCIE_CLKOUT0N)
CLK_PCIE_SSDP: CN5.55 U21.C11(PCIE_CLKOUT0P)
CLK_PCIE_WLANN: CN9.49 U21.B5(PCIE_CLKOUT3N)
CLK_PCIE_WLANP: CN9.47 U21.B7(PCIE_CLKOUT3P)
CLK_SCLK: Q29.1(S) R38.1 U17.4(SCL/SPC)
CLK_SDATA: Q29.4(S) R45.1 U17.6(SDA/SDI/SDO)
CLKDRV_RCOMP: R42.2 U21.E21(PCIE_REF_CLK_RCOMP)
CLKREQ_SSD#: CN5.52 Q36.5(G) R484.2 U4.4(B)
CLKREQ_WLAN#: CN9.53 Q35.5(G) R483.2 U29.4(B)
CLKRUN#: C233.2 R371.2 U14.13(C\L\K\R\U\N\/GPIO04/S\I\N\T\) U16.93(CLKRUN#/ID0/GPH0)
CLKRUN#_R: R371.1 U21.V62(LPC_CLKRUN_N)
CLR_CMOS: Q11.2(G) Q11.5(G) R254.1 U16.79(DAC3/TACH1B/GPJ3(3))
CODEC_VREF: C249.2 U15.28(VREF)
D/C#: PR189.2 U16.3(GPH7)
DDCCLK_NOR: Q10.4(S) R103.2 R104.1
DDCCLK_NOR-1: Q10.3(D) R108.2
DDCCLK_RIN: R120.1 U6.7(SCL_SOURCE)
DDCCLK_ROUT: R107.2 U6.19(SCL_SINK)
DDCDATA_NOR: Q10.1(S) R112.2 R113.1
DDCDATA_NOR-1: Q10.6(D) R115.2
DDCDATA_RIN: R121.1 U6.6(SDA_SOURCE)
DDCDATA_ROUT: R114.2 U6.20(SDA_SINK)
DDI0_RCOMP_N: R385.1 U21.AG2(DDI0_RCOMP_N)
DDI0_RCOMP_P: R385.2 U21.AG1(DDI0_RCOMP_P)
DE1: R220.1 R452.2 U12.9(DE1)
DE2: R219.1 R453.2 U12.8(DE2)
DEW1: R444.1 R447.2 U12.16(DEW1)
DEW2: R217.1 R218.2 U12.6(DEW2)
DMIC_CLK: C241.1 D14.2 R243.1 R280.1
DMIC_CLK_C: CN3.1 R280.2
DMIC_CLK_R: R243.2 U15.3(GPIO1/DMIC-CLK)
DMIC_DAT: CN3.2 D13.2 R240.2
DMIC_DAT_R: R240.1 U15.2(GPIO0/DMIC-DATA)
DNBSWON#: U16.123(CTX0/TMA0/GPB2(3)) U21.AK55(PMU_PWRBTN_N)
DUALDMIC_PWR: CN3.29 R3.2 R4.2
EC_FPBACK#: Q2.2(BASE) U16.86(PS2DAT0/TMB1/GPF1)
EC_PWROK: C79.1 R81.2 R481.1 U16.33(GINT/CTS0#/GPD5) U21.AG49(SOC_PWROK)
EC_TYPEC_CHG_HI: R49.2 U16.97(ID4/GPH4)
EC_TYPEC_EN: R56.2 U3.6(EN) U16.80(DAC4/DCD0#/GPJ4(3))
ECAGND: C267.2 C272.1 L5.1 U16.75(AVSS)
EDP_AUXN: C286.1 U21.AH9(EDP_AUXN)
EDP_AUXN_C: C286.2 CN3.22 R279.1
EDP_AUXP: C285.1 U21.AH10(EDP_AUXP)
EDP_AUXP_C: C285.2 CN3.23 R278.1
EDP_HPD: C1.2 Q1.2(G) R1.1 R2.1
EDP_HPD_R: CN3.25 R1.2
EDP_RCOMP_N: R74.1 U21.AG5(EDP_RCOMP_N)
EDP_RCOMP_P: R74.2 U21.AG6(EDP_RCOMP_P)
EDP_TXN0: C288.1 U21.AG9(EDP_TXN_0)
EDP_TXN0_C: C288.2 CN3.19
EDP_TXN1: C290.1 U21.AG10(EDP_TXN_1)
EDP_TXN1_C: C290.2 CN3.16
EDP_TXN2: C294.1 U21.AC5(EDP_TXN_2)
EDP_TXN2_C: C294.2 CN3.13
EDP_TXN3: C299.1 U21.AC9(EDP_TXN_3)
EDP_TXN3_C: C299.2 CN3.10
EDP_TXP0: C287.1 U21.AG7(EDP_TXP_0)
EDP_TXP0_C: C287.2 CN3.20
EDP_TXP1: C289.1 U21.AG12(EDP_TXP_1)
EDP_TXP1_C: C289.2 CN3.17
EDP_TXP2: C291.1 U21.AC6(EDP_TXP_2)
EDP_TXP2_C: C291.2 CN3.14
EDP_TXP3: C295.1 U21.AC7(EDP_TXP_3)
EDP_TXP3_C: C295.2 CN3.11
EDP_VDD_EN: Q27.6(D) R281.2 R336.1 U19.3(EN)
EMMC_CLK: R331.1 U21.Y58(EMMC_CLK)
EMMC_CLK_R: C318.1 R331.2 R355.2 U2.W6(CLK)
EMMC_CMD: U2.W5(CMD) U21.Y51(EMMC_CMD)
EMMC_DATA_0: TP5.1 U2.H3(DAT0) U21.V58(EMMC_D0)
EMMC_DATA_1: U2.H4(DAT1) U21.T58(EMMC_D1)
EMMC_DATA_2: U2.H5(DAT2) U21.T59(EMMC_D2)
EMMC_DATA_3: U2.J2(DAT3) U21.V51(EMMC_D3)
EMMC_DATA_4: U2.J3(DAT4) U21.V52(EMMC_D4)
EMMC_DATA_5: U2.J4(DAT5) U21.Y49(EMMC_D5)
EMMC_DATA_6: U2.J5(DAT6) U21.V55(EMMC_D6)
EMMC_DATA_7: U2.J6(DAT7) U21.V57(EMMC_D7)
EMMC_ID0: R287.2 R295.1 U21.H34(GPIO_31)
EMMC_ID1: R283.2 R291.1 U21.F35(GPIO_32)
EMMC_RCLK: R357.1 U2.R5(NC_73) U21.V54(EMMC_RCLK)
EMMC_RCOMP: R58.2 U21.V59(EMMC_RCOMP)
EMMC_RST#: D2.2(ANODE) R63.2 U2.U5(RESET)
EN: R216.1 R451.2 U12.7(EN)
EQ1: R169.1 R170.2 U12.17(EQ1)
EQ2: R171.2 R172.1 U12.19(EQ2)
FAN1_RPM: C218.1 CN10.2 R223.2 U16.47(TACH0A/GPD6(3))
FAN_PWM: Q16.1(EMITTER) U16.32(PWM6/SSCK/GPA6)
FAN_PWM_Q: C216.1 CN10.3 Q16.3(COLLECTOR) R229.2
FCCM_A: PR90.2 PR103.1
FCCM_C: PR89.2 PR108.1
G5719LX1.8V: PL7.1 PU12.3(LX)
G5719LX1.24V: PL6.1 PU10.3(LX)
GPC6: R202.1 R207.1 U16.124(TMRI1/GPC6(3))
GPIO_23: Q4.6(D) U21.B25(GPIO_23)
GPIO_24: Q25.5(G) U21.C25(GPIO_24)
GPIO_25: Q24.5(G) U21.C27(GPIO_25)
GPIO_34: R346.2 U21.B41(PWM0)
GPIO_35: R313.2 U21.C41(PWM1)
GPIO_36: R27.1 R33.1 U21.F41(PWM2)
GPIO_39: R310.1 R343.1 U21.B45(LPSS_UART0_TXD)
GPIO_40: R334.2 U21.A46(LPSS_UART0_RTS_N)
GPIO_43: R311.1 R344.1 U21.B43(LPSS_UART1_TXD)
GPIO_44: R312.1 R345.1 U21.A42(LPSS_UART1_RTS_N)
GPIO_47: R28.1 R32.2 U21.H41(LPSS_UART2_TXD)
GPIO_48: R54.2 U21.L41(LPSS_UART2_RTS_N)
GPIO_78: R360.2 R364.2 U21.K62(AVS_I2S1_SDO)
GPIO_82: R59.2 U21.M55(AVS_DMIC_CLK_AB2)
GPIO_88: R19.2 R31.1 U21.M58(AVS_I2S2_SDO)
GPIO_92: R363.1 R367.1 U21.L63(AVS_I2S3_SDO)
GPIO_104: R41.2 U21.F54(SIO_SPI_0_CLK)
GPIO_105: R43.2 U21.F52(SIO_SPI_0_FS0)
GPIO_106: R20.2 U21.H52(SIO_SPI_0_FS1)
GPIO_110: R16.1 R36.2 U21.J52(SIO_SPI_0_TXD)
GPIO_111: R26.2 R29.2 U21.F58(SIO_SPI_1_CLK)
GPIO_112: R57.2 U21.K55(SIO_SPI_1_FS0)
GPIO_113: R39.2 U21.F61(SIO_SPI_1_FS1)
GPIO_117: R55.2 U21.H58(SIO_SPI_1_TXD)
GPIO_120: R18.1 R30.1 U21.E56(SIO_SPI_2_FS1)
GPIO_121: R35.2 U21.D59(SIO_SPI_2_FS2)
GPIO_123: R356.2 U21.E62(SIO_SPI_2_TXD)
GPIO_RCOMP: R34.2 U21.E34(GPIO_RCOMP)
H_CPU_SVIDCLK: PR122.2 PR123.2 U21.C17(SVID0_CLK)
H_CPU_SVIDDAT: PR24.1 PR27.2 R323.2 U21.C18(SVID0_DATA)
H_PROCHOT#: PQ8.3(D) PR50.1 PR127.2 Q17.3(D) R17.1 U21.E47(PROCHOT_N)
HDA_BCLK_R: R98.2 U21.AM48(ISH_GPIO_0)
HDA_RST#_R: R52.2 U21.K58(AVS_I2S2_MCLK)
HDA_SDO_R: R95.2 U21.AM54(ISH_GPIO_3)
HDA_SYNC_R: R399.2 U21.AK58(ISH_GPIO_1)
HDD+M2_PWR: C235.2 C239.2 C244.2 C248.1 C399.2 C409.2 CN11.1 CN11.2 CN12.3 CN12.4 CN12.5 CN12.6 R252.1 R260.1
HDMI_5V: C353.1 CN6.18(+5V) D30.1 R110.1 R116.1 U5.1(OUT)
HDMI_DDCCLK: CN6.15(DDC_CLK) D4.2 R107.1 R108.1 R110.2
HDMI_DDCCLK_SW: R104.2 R120.2 U21.B49(DDI0_DDC_SCL)
HDMI_DDCDATA: CN6.16(DDC_DATA) D5.2 R114.1 R115.1 R116.2
HDMI_DDCDATA_SW: R113.2 R121.2 U21.C49(DDI0_DDC_SDA)
HDMI_EQ0: R111.1 R119.1 U6.8(EQ0)
HDMI_EQ1: R109.1 R118.1 U6.2(EQ1)
HDMI_HPD: CN6.19(HP_DET) D29.1 R400.1 R401.1 R402.1
HDMI_HPD_NOR: Q9.3(D) R99.1
HDMI_HPD_NOR-1: Q9.2(G) R402.2
HDMI_HPD_RIN: Q12.2(G) U6.5(HPD_SOURCE)
HDMI_HPD_RIN_Q: Q12.3(D) R100.1
HDMI_HPD_ROUT: R401.2 U6.21(HPD_SINK)
HP-L2: C423.2 R465.1 R466.2 U15.32(HP-OUT-L)
HP-L3: C417.2 CN17.31 R466.1
HP-R2: C444.2 R244.2 R476.1 U15.33(HP-OUT-R)
HP-R3: C243.2 CN17.33 R244.1
HP_JD#: CN17.22 R257.2
HWPG: D15.2(ANODE) D16.2(ANODE) D17.2(ANODE) D18.2(ANODE) D19.2(ANODE) D20.2(ANODE) R443.1 U16.21(RI2#/GPD1)
HWPG_1.05V: D17.1(CATHODE) PR144.2 PR145.2
HWPG_1.5V: D20.1(CATHODE) PR186.2 PU14.1(POK)
HWPG_1.8V_S5: D18.1(CATHODE) PR160.2 PR163.2 PR165.2
HWPG_1.24V_S5: D19.1(CATHODE) PR149.2 PR152.2
HWPG_1.35VSUS: D15.1(CATHODE) PR196.1 PR197.2
I2C4_SCL: Q21.4(S) R92.2 U21.AP54(LPSS_I2C4_SCL)
I2C4_SCL_C: CN15.6 ESD4.6 Q21.3(D) R268.1
I2C4_SDA: Q21.1(S) R90.2 U21.AP52(LPSS_I2C4_SDA)
I2C4_SDA_C: CN15.5 ESD4.1 Q21.6(D) R264.1
ICMNT: C272.2 PC53.2 PR54.1 PU2.7(IOUT) U16.67(ADC1/GPI1(3))
IMVP_PWRGD: D16.1(CATHODE) PR129.2 PR130.2
INT_AMIC-VREFO: C255.1 R251.2 U15.27(LDO1-CAP)
INT_EDP_HPD#: Q1.3(D) U21.P48(PMC_SPI_FS1)
INT_HDMI_HPD#: R99.2 R100.2 U21.C50(GPIO_200)
INT_HDMICLK+: C110.1 C111.1 U21.AL2(DDI0_TXP_3)
INT_HDMICLK+_C: CN6.10(CLK+) ESD6.4(LINE-3) ESD6.7(NC#2) R125.1 R404.1
INT_HDMICLK+_C_RIN: C110.2 U6.31(IN_D4-)
INT_HDMICLK+_C_ROUT: R125.2 U6.10(OUT_D4-)
INT_HDMICLK+_NOR: C111.2 R126.1 R404.2
INT_HDMICLK-: C107.1 C108.1 U21.AL1(DDI0_TXN_3)
INT_HDMICLK-_C: CN6.12(CLK-) ESD6.5(LINE-4) ESD6.6(NC#1) R123.1 R403.1
INT_HDMICLK-_C_RIN: C107.2 U6.32(IN_D4+)
INT_HDMICLK-_C_ROUT: R123.2 U6.9(OUT_D4+)
INT_HDMICLK-_NOR: C108.2 R122.1 R403.2
INT_HDMITX0N: C122.1 C123.1 U21.AH2(DDI0_TXN_2)
INT_HDMITX0N_C: CN6.9(D0-) ESD7.2(LINE-2) ESD7.9(NC#3) R140.1 R409.1
INT_HDMITX0N_C_RIN: C122.2 U6.26(IN_D1+)
INT_HDMITX0N_C_ROUT: R140.2 U6.15(OUT_D1+)
INT_HDMITX0N_NOR: C123.2 R139.1 R409.2
INT_HDMITX0P: C124.1 C125.1 U21.AH3(DDI0_TXP_2)
INT_HDMITX0P_C: CN6.7(D0+) ESD7.1(LINE-1) ESD7.10(NC#4) R142.1 R410.1
INT_HDMITX0P_C_RIN: C124.2 U6.25(IN_D1-)
INT_HDMITX0P_C_ROUT: R142.2 U6.16(OUT_D1-)
INT_HDMITX0P_NOR: C125.2 R143.1 R410.2
INT_HDMITX1N: C116.1 C117.1 U21.AM2(DDI0_TXN_1)
INT_HDMITX1N_C: CN6.6(D1-) ESD7.5(LINE-4) ESD7.6(NC#1) R135.1 R407.1
INT_HDMITX1N_C_RIN: C116.2 U6.28(IN_D2+)
INT_HDMITX1N_C_ROUT: R135.2 U6.13(OUT_D2+)
INT_HDMITX1N_NOR: C117.2 R134.1 R407.2
INT_HDMITX1P: C118.1 C119.1 U21.AM3(DDI0_TXP_1)
INT_HDMITX1P_C: CN6.4(D1+) ESD7.4(LINE-3) ESD7.7(NC#2) R137.1 R408.1
INT_HDMITX1P_C_RIN: C118.2 U6.27(IN_D2-)
INT_HDMITX1P_C_ROUT: R137.2 U6.14(OUT_D2-)
INT_HDMITX1P_NOR: C119.2 R138.1 R408.2
INT_HDMITX2N: C112.1 C113.1 U21.AK2(DDI0_TXN_0)
INT_HDMITX2N_C: CN6.3(D2-) ESD6.2(LINE-2) ESD6.9(NC#3) R130.1 R405.1
INT_HDMITX2N_C_RIN: C112.2 U6.30(IN_D3+)
INT_HDMITX2N_C_ROUT: R130.2 U6.11(OUT_D3+)
INT_HDMITX2N_NOR: C113.2 R129.1 R405.2
INT_HDMITX2P: C114.1 C115.1 U21.AK3(DDI0_TXP_0)
INT_HDMITX2P_C: CN6.1(D2+) ESD6.1(LINE-1) ESD6.10(NC#4) R132.1 R406.1
INT_HDMITX2P_C_RIN: C114.2 U6.29(IN_D3-)
INT_HDMITX2P_C_ROUT: R132.2 U6.12(OUT_D3-)
INT_HDMITX2P_NOR: C115.2 R133.1 R406.2
INTRUDER#: R62.1 U21.AC54(INTRUDER)
IRQ_SERIRQ: U16.5(SERIRQ/GPM6(3)) U22.3(A)
ISL95857_COMP_A: PC18.2 PR120.1 PU6.16(COMP_A)
ISL95857_COMP_C: PC10.2 PR105.1 PU6.24(COMP_C)
ISL95857_FB_A: PR23.1 PR26.1 PR118.1 PU6.17(FB_A)
ISL95857_FB_C: PR13.1 PR106.1 PR107.1 PU6.25(FB_C)
ISL95857_FCCM_A: PR103.2 PU6.21(FCCM_A)
ISL95857_FCCM_C: PR108.2 PU6.29(FCCM_C)
ISL95857_IMON_A: PC100.1 PR128.1 PU6.14(IMON_A)
ISL95857_IMON_C: PC9.1 PR11.1 PU6.23(IMON_C)
ISL95857_ISUMN_A: PC91.2 PR111.1 PU6.20(ISUMN_A)
ISL95857_ISUMN_C: PC87.2 PR14.1 PU6.28(ISUMN_C)
ISL95857_NTC_A: PR32.1 PR113.1 PU6.15(NTC_A)
ISL95857_PROG1: PR20.1 PU6.32(PROG1)
ISL95857_PROG2: PR18.1 PU6.31(PROG2)
ISL95857_PSYS: PU6.1(PSYS) TP30.1
ISL95857_PWM_A: PR104.2 PU6.22(PWM_A)
ISL95857_PWM_C: PR112.2 PU6.30(PWM_C)
ISL95857_RTN_A: PC17.2 PC98.2 PR21.1 PR119.2 PU6.18(RTN_A)
ISL95857_RTN_C: PC4.2 PC5.2 PR96.1 PR97.2 PU6.26(RTN_C)
ISL95857_SCLK: PR123.1 PU6.37(SCLK)
ISL95857_SDA: PR24.2 PU6.35(SDA)
ISL95857_VCC: PC95.1 PR117.2 PU6.34(VCC)
ISL95857_VIN: PC92.1 PR114.1 PU6.33(VIN)
ISL95857_VR_EN: PR133.1 PU6.40(VR_ENABLE)
ISL95857_VR_HOT: PR127.1 PU6.38(VR_HOT#)
ISL95857_VR_READY: PR130.1 PU6.39(VR_READY)
ISOLATEB: R224.2 R225.1 U13.31(ISOLATEB)
ISUMN_A: PC12.2 PC89.1 PC90.1 PR19.1 PR111.2 PR115.2 PR116.2 PR126.1
ISUMN_C: PC6.1 PC11.1 PC86.2 PR14.2 PR94.1 PR100.1 PR101.2 PR110.2
ISUMP_A: PC12.1 PC90.2 PR19.2 PR22.2 PR121.1 PU6.19(ISUMP_A)
ISUMP_C: PC11.2 PC86.1 PR6.2 PR91.1 PR100.2 PU6.27(ISUMP_C)
KB_BL_LED: Q23.2(BASE) U16.113(CRX0/GPC0)
KBRST#: TP20.1 U16.4(KBRST#/GPB6(3))
L_SPK+: C433.1 CN19.4 U15.42(SPK-L+)
L_SPK-: C432.1 CN19.3 U15.43(SPK-L-)
LAN_MCT0: R15.1 U20.24(NC #4)
LAN_MCT1: R14.1 U20.21(NC #3)
LAN_MCT2: R13.1 U20.18(NC #2)
LAN_MCT3: R12.1 U20.15(NC #1)
LAN_MX0+: CN4.1 U20.23(MX1+)
LAN_MX0-: CN4.2 U20.22(MX1-)
LAN_MX1+: CN4.3 U20.20(MX2+)
LAN_MX1-: CN4.6 U20.19(MX2-)
LAN_MX2+: CN4.4 U20.17(MX3+)
LAN_MX2-: CN4.5 U20.16(MX3-)
LAN_MX3+: CN4.7 U20.14(MX4+)
LAN_MX3-: CN4.8 U20.13(MX4-)
LAN_XTAL2: C179.2 U13.45(CKXTAL2) Y2.3
LAN_XTALI: C180.2 U13.44(CKXTAL1) Y2.1
LANVCC: C176.2 C186.2 C187.2 C188.1 C200.1 C202.2 C203.2 C204.2 C215.2 R168.1 R209.1 R226.1 U13.11(AVDD33#1) U13.32(DVDD33) U13.35(VDDREG) U13.48(AVDD33)
LCDVCC: C306.2 C308.1 C311.1 R275.1 U19.1(OUT)
LCDVCC_R: CN3.34 CN3.35 CN3.36 R274.1 R275.2
LID#: D1.1(CATHODE) Q14.1(OUTPUT) R204.2
LINE1-L: C423.1 U15.22(LINE1-L)
LINE1-R: C444.1 U15.21(LINE1-R)
LINE1-VREFO-L: R465.2 U15.31(LINE1-VREFO-L)
LINE1-VREFO-R: R476.2 U15.30(LINE1-VREFO-R)
LPC_CLKOUT0: R379.1 U21.AB61(LPC_CLKOUT0)
LPC_CLKOUT1: C336.1 R376.1 R380.1 U21.AA62(LPC_CLKOUT1)
LPC_LAD0: CN9.64 R374.2 U14.24(LAD0/MISO) U16.10(LAD0/GPM0(3))
LPC_LAD0_R: R374.1 U21.Y61(LPC_AD0)
LPC_LAD1: CN9.66 R375.2 U14.21(LAD1/MOSI) U16.9(LAD1/GPM1(3))
LPC_LAD1_R: R375.1 U21.Y62(LPC_AD1)
LPC_LAD2: CN9.68 R370.2 U14.18(LAD2/S\P\I\_\I\R\Q\) U16.8(LAD2/GPM2(3))
LPC_LAD2_R: R370.1 U21.W62(LPC_AD2)
LPC_LAD3: CN9.70 R372.2 U14.15(LAD3) U16.7(LAD3/GPM3(3))
LPC_LAD3_R: R372.1 U21.W63(LPC_AD3)
LPC_LFRAME#: R369.2 R464.2 U14.20(L\F\R\A\M\E\/S\C\S\) U16.6(LFRAME#/GPM5(3))
LPC_LFRAME#_C: CN9.73 R464.1
LPC_LFRAME#_R: R369.1 U21.V61(LPC_FRAME_N)
M_A_A0: R427.2 U8.N3(A0) U9.N3(A0) U21.BG50(DDR3L_CH0_MA0_LPDDR3_CH0_CAB7) U24.N3(A0) U25.N3(A0)
M_A_A1: R188.2 U8.P7(A1) U9.P7(A1) U21.BG51(DDR3L_CH0_MA1_LPDDR3_CH0_CAB9) U24.P7(A1) U25.P7(A1)
M_A_A2: R189.2 U8.P3(A2) U9.P3(A2) U21.BH51(DDR3L_CH0_MA2_LPDDR3_CH0_CAB5) U24.P3(A2) U25.P3(A2)
M_A_A3: R425.2 U8.N2(A3) U9.N2(A3) U21.BD41(DDR3L_CH0_MA3_LPDDR3_NC) U24.N2(A3) U25.N2(A3)
M_A_A4: R185.2 U8.P8(A4) U9.P8(A4) U21.BE41(DDR3L_CH0_MA4_LPDDR3_NC) U24.P8(A4) U25.P8(A4)
M_A_A5: R184.2 U8.P2(A5) U9.P2(A5) U21.BJ52(DDR3L_CH0_MA5_LPDDR3_CH0_CAA2) U24.P2(A5) U25.P2(A5)
M_A_A6: R183.2 U8.R8(A6) U9.R8(A6) U21.BG53(DDR3L_CH0_MA6_LPDDR3_CH0_CAA0) U24.R8(A6) U25.R8(A6)
M_A_A7: R182.2 U8.R2(A7) U9.R2(A7) U21.BG55(DDR3L_CH0_MA7_LPDDR3_CH0_CAA3) U24.R2(A7) U25.R2(A7)
M_A_A8: R424.2 U8.T8(A8) U9.T8(A8) U21.BH53(DDR3L_CH0_MA8_LPDDR3_CH0_CAA1) U24.T8(A8) U25.T8(A8)
M_A_A9: R180.2 U8.R3(A9) U9.R3(A9) U21.BG52(DDR3L_CH0_MA9_LPDDR3_CH0_CAA4) U24.R3(A9) U25.R3(A9)
M_A_A10: R430.2 U8.L7(A10/AP) U9.L7(A10/AP) U21.BH49(DDR3L_CH0_MA10_LPDDR3_CH0_CAB6) U24.L7(A10/AP) U25.L7(A10/AP)
M_A_A11: R179.2 U8.R7(A11) U9.R7(A11) U21.BH55(DDR3L_CH0_MA11_LPDDR3_CH0_CAA6) U24.R7(A11) U25.R7(A11)
M_A_A12: R178.2 U8.N7(A12/B\C\) U9.N7(A12/B\C\) U21.BG54(DDR3L_CH0_MA12_LPDDR3_CH0_CAA5) U24.N7(A12/B\C\) U25.N7(A12/B\C\)
M_A_A13: R186.2 U8.T3(A13) U9.T3(A13) U21.BG46(DDR3L_CH0_MA13_LPDDR3_CH0_CAB0) U24.T3(A13) U25.T3(A13)
M_A_A14: R181.2 U8.T7(A14) U9.T7(A14) U21.BG56(DDR3L_CH0_MA14_LPDDR3_CH0_CAA8) U24.T7(A14) U25.T7(A14)
M_A_A15: R421.2 U8.M7(A15/NC) U9.M7(A15/NC) U21.BG57(DDR3L_CH0_MA15_LPDDR3_CH0_CAA9) U24.M7(A15/NC) U25.M7(A15/NC)
M_A_BS#0: R428.2 U8.M2(BA0) U9.M2(BA0) U21.BJ48(DDR3L_CH0_BA0_LPDDR3_CH0_CAB2) U24.M2(BA0) U25.M2(BA0)
M_A_BS#1: R187.2 U8.N8(BA1) U9.N8(BA1) U21.BG49(DDR3L_CH0_BA1_LPDDR3_CH0_CAB8) U24.N8(BA1) U25.N8(BA1)
M_A_BS#2: R422.2 U8.M3(BA2) U9.M3(BA2) U21.BH57(DDR3L_CH0_BA2_LPDDR3_CH0_CAA7) U24.M3(BA2) U25.M3(BA2)
M_A_CAS#: R426.2 U8.K3(C\A\S\) U9.K3(C\A\S\) U21.BH47(DDR3L_CH0_CAS_N_LPDDR3_CH0_CAB1) U24.K3(C\A\S\) U25.K3(C\A\S\)
M_A_CKE0: R419.2 U8.K9(CKE) U9.K9(CKE) U21.BH61(DDR3L_CH0_CKE0_LPDDR3_CH0_CKE0A) U24.K9(CKE) U25.K9(CKE)
M_A_CLK0: R154.2 U8.J7(CK) U9.J7(CK) U21.BD45(DDR3L_CH0_CLKP0_LPDDR3_CH0_CLKP) U24.J7(CK) U25.J7(CK)
M_A_CLK0#: R154.1 U8.K7(C\K\) U9.K7(C\K\) U21.BE45(DDR3L_CH0_CLKN0_LPDDR3_CH0_CLKN) U24.K7(C\K\) U25.K7(C\K\)
M_A_CS#0: R420.2 U8.L2(C\S\) U9.L2(C\S\) U21.AR43(DDR3L_CH0_CS0_N_LPDDR3_CH0_CS0A) U24.L2(C\S\) U25.L2(C\S\)
M_A_DQ0: U21.AY62(DDR3L_CH0_DQ0_LPDDR3_CH0_DQA0) U24.H8(DQL5/DQ5)
M_A_DQ1: U21.AY61(DDR3L_CH0_DQ1_LPDDR3_CH0_DQA1) U24.G2(DQL6/DQ6)
M_A_DQ2: U21.BE62(DDR3L_CH0_DQ2_LPDDR3_CH0_DQA2) U24.F2(DQL2/DQ2)
M_A_DQ3: U21.BG62(DDR3L_CH0_DQ3_LPDDR3_CH0_DQA3) U24.F7(DQL1/DQ1)
M_A_DQ4: U21.BD63(DDR3L_CH0_DQ4_LPDDR3_CH0_DQA4) U24.F8(DQL3/DQ3)
M_A_DQ5: U21.AW62(DDR3L_CH0_DQ5_LPDDR3_CH0_DQA5) U24.H7(DQL7/DQ7)
M_A_DQ6: U21.AW63(DDR3L_CH0_DQ6_LPDDR3_CH0_DQA6) U24.H3(DQL4/DQ4)
M_A_DQ7: U21.BD62(DDR3L_CH0_DQ7_LPDDR3_CH0_DQA7) U24.E3(DQL0/DQ0)
M_A_DQ8: U21.AV59(DDR3L_CH0_DQ8_LPDDR3_CH0_DQA8) U24.C2(DQU3/DQ11)
M_A_DQ9: U21.AU63(DDR3L_CH0_DQ9_LPDDR3_CH0_DQA9) U24.C8(DQU2/DQ10)
M_A_DQ10: U21.AU62(DDR3L_CH0_DQ10_LPDDR3_CH0_DQA10) U24.D7(DQU0/DQ8)
M_A_DQ11: U21.AV58(DDR3L_CH0_DQ11_LPDDR3_CH0_DQA11) U24.A2(DQU5/DQ13)
M_A_DQ12: U21.AV57(DDR3L_CH0_DQ12_LPDDR3_CH0_DQA12) U24.C3(DQU1/DQ9)
M_A_DQ13: U21.AT55(DDR3L_CH0_DQ13_LPDDR3_CH0_DQA13) U24.A7(DQU4/DQ12)
M_A_DQ14: U21.AT54(DDR3L_CH0_DQ14_LPDDR3_CH0_DQA14) U24.B8(DQU6/DQ14)
M_A_DQ15: U21.AY59(DDR3L_CH0_DQ15_LPDDR3_CH0_DQA15) U24.A3(DQU7/DQ15)
M_A_DQ16: U8.H7(DQL7/DQ7) U21.AY57(DDR3L_CH0_DQ16_LPDDR3_CH0_DQA16)
M_A_DQ17: U8.F8(DQL3/DQ3) U21.BB57(DDR3L_CH0_DQ17_LPDDR3_CH0_DQA17)
M_A_DQ18: U8.F7(DQL1/DQ1) U21.BD59(DDR3L_CH0_DQ18_LPDDR3_CH0_DQA18)
M_A_DQ19: U8.E3(DQL0/DQ0) U21.BF59(DDR3L_CH0_DQ19_LPDDR3_CH0_DQA19)
M_A_DQ20: U8.H8(DQL5/DQ5) U21.AV54(DDR3L_CH0_DQ20_LPDDR3_CH0_DQA20)
M_A_DQ21: U8.H3(DQL4/DQ4) U21.AY55(DDR3L_CH0_DQ21_LPDDR3_CH0_DQA21)
M_A_DQ22: U8.G2(DQL6/DQ6) U21.AV52(DDR3L_CH0_DQ22_LPDDR3_CH0_DQA22)
M_A_DQ23: U8.F2(DQL2/DQ2) U21.BD58(DDR3L_CH0_DQ23_LPDDR3_CH0_DQA23)
M_A_DQ24: U8.C2(DQU3/DQ11) U21.BE56(DDR3L_CH0_DQ24_LPDDR3_CH0_DQA24)
M_A_DQ25: U8.A3(DQU7/DQ15) U21.BD54(DDR3L_CH0_DQ25_LPDDR3_CH0_DQA25)
M_A_DQ26: U8.A2(DQU5/DQ13) U21.BF58(DDR3L_CH0_DQ26_LPDDR3_CH0_DQA26)
M_A_DQ27: U8.A7(DQU4/DQ12) U21.BE50(DDR3L_CH0_DQ27_LPDDR3_CH0_DQA27)
M_A_DQ28: U8.D7(DQU0/DQ8) U21.BD50(DDR3L_CH0_DQ28_LPDDR3_CH0_DQA28)
M_A_DQ29: U8.B8(DQU6/DQ14) U21.BB50(DDR3L_CH0_DQ29_LPDDR3_CH0_DQA29)
M_A_DQ30: U8.C8(DQU2/DQ10) U21.BA50(DDR3L_CH0_DQ30_LPDDR3_CH0_DQA30)
M_A_DQ31: U8.C3(DQU1/DQ9) U21.BB54(DDR3L_CH0_DQ31_LPDDR3_CH0_DQA31)
M_A_DQ32: U9.F8(DQL3/DQ3) U21.AR39(DDR3L_CH0_DQ32_LPDDR3_CH0_DQB0)
M_A_DQ33: U9.H8(DQL5/DQ5) U21.AV37(DDR3L_CH0_DQ33_LPDDR3_CH0_DQB1)
M_A_DQ34: U9.H7(DQL7/DQ7) U21.AW37(DDR3L_CH0_DQ34_LPDDR3_CH0_DQB2)
M_A_DQ35: U9.F7(DQL1/DQ1) U21.AR37(DDR3L_CH0_DQ35_LPDDR3_CH0_DQB3)
M_A_DQ36: U9.G2(DQL6/DQ6) U21.AT37(DDR3L_CH0_DQ36_LPDDR3_CH0_DQB4)
M_A_DQ37: U9.F2(DQL2/DQ2) U21.AT41(DDR3L_CH0_DQ37_LPDDR3_CH0_DQB5)
M_A_DQ38: U9.E3(DQL0/DQ0) U21.AR41(DDR3L_CH0_DQ38_LPDDR3_CH0_DQB6)
M_A_DQ39: U9.H3(DQL4/DQ4) U21.AW35(DDR3L_CH0_DQ39_LPDDR3_CH0_DQB7)
M_A_DQ40: U21.BJ44(DDR3L_CH0_DQ40_LPDDR3_CH0_DQB8) U25.D7(DQU0/DQ8)
M_A_DQ41: U21.BG39(DDR3L_CH0_DQ41_LPDDR3_CH0_DQB9) U25.C2(DQU3/DQ11)
M_A_DQ42: U21.BG40(DDR3L_CH0_DQ42_LPDDR3_CH0_DQB10) U25.A3(DQU7/DQ15)
M_A_DQ43: U21.BJ40(DDR3L_CH0_DQ43_LPDDR3_CH0_DQB11) U25.C3(DQU1/DQ9)
M_A_DQ44: U21.BG43(DDR3L_CH0_DQ44_LPDDR3_CH0_DQB12) U25.A7(DQU4/DQ12)
M_A_DQ45: U21.BG44(DDR3L_CH0_DQ45_LPDDR3_CH0_DQB13) U25.B8(DQU6/DQ14)
M_A_DQ46: U21.BH45(DDR3L_CH0_DQ46_LPDDR3_CH0_DQB14) U25.C8(DQU2/DQ10)
M_A_DQ47: U21.BH41(DDR3L_CH0_DQ47_LPDDR3_CH0_DQB15) U25.A2(DQU5/DQ13)
M_A_DQ48: U9.A7(DQU4/DQ12) U21.BA34(DDR3L_CH0_DQ48_LPDDR3_CH0_DQB16)
M_A_DQ49: U9.B8(DQU6/DQ14) U21.BE34(DDR3L_CH0_DQ49_LPDDR3_CH0_DQB17)
M_A_DQ50: U9.C8(DQU2/DQ10) U21.BD34(DDR3L_CH0_DQ50_LPDDR3_CH0_DQB18)
M_A_DQ51: U9.C3(DQU1/DQ9) U21.BD37(DDR3L_CH0_DQ51_LPDDR3_CH0_DQB19)
M_A_DQ52: U9.C2(DQU3/DQ11) U21.BB37(DDR3L_CH0_DQ52_LPDDR3_CH0_DQB20)
M_A_DQ53: U9.A3(DQU7/DQ15) U21.BE39(DDR3L_CH0_DQ53_LPDDR3_CH0_DQB21)
M_A_DQ54: U9.A2(DQU5/DQ13) U21.BD39(DDR3L_CH0_DQ54_LPDDR3_CH0_DQB22)
M_A_DQ55: U9.D7(DQU0/DQ8) U21.BB34(DDR3L_CH0_DQ55_LPDDR3_CH0_DQB23)
M_A_DQ56: U21.BJ38(DDR3L_CH0_DQ56_LPDDR3_CH0_DQB24) U25.F2(DQL2/DQ2)
M_A_DQ57: U21.BG34(DDR3L_CH0_DQ57_LPDDR3_CH0_DQB25) U25.H3(DQL4/DQ4)
M_A_DQ58: U21.BG33(DDR3L_CH0_DQ58_LPDDR3_CH0_DQB26) U25.G2(DQL6/DQ6)
M_A_DQ59: U21.BH33(DDR3L_CH0_DQ59_LPDDR3_CH0_DQB27) U25.H8(DQL5/DQ5)
M_A_DQ60: U21.BG38(DDR3L_CH0_DQ60_LPDDR3_CH0_DQB28) U25.F7(DQL1/DQ1)
M_A_DQ61: U21.BH37(DDR3L_CH0_DQ61_LPDDR3_CH0_DQB29) U25.F8(DQL3/DQ3)
M_A_DQ62: U21.BG37(DDR3L_CH0_DQ62_LPDDR3_CH0_DQB30) U25.E3(DQL0/DQ0)
M_A_DQ63: U21.BJ34(DDR3L_CH0_DQ63_LPDDR3_CH0_DQB31) U25.H7(DQL7/DQ7)
M_A_DQS0: U21.BB63(DDR3L_CH0_DQSP0_LPDDR3_CH0_DQSP) U24.F3(DQSL)
M_A_DQS1: U21.AT59(DDR3L_CH0_DQSP1_LPDDR3_CH0_DQSP) U24.C7(DQSU)
M_A_DQS2: U8.F3(DQSL) U21.BB59(DDR3L_CH0_DQSP2_LPDDR3_CH0_DQSP)
M_A_DQS3: U8.C7(DQSU) U21.BD52(DDR3L_CH0_DQSP3_LPDDR3_CH0_DQSP)
M_A_DQS4: U9.F3(DQSL) U21.AV39(DDR3L_CH0_DQSP4_LPDDR3_CH0_DQSP)
M_A_DQS5: U21.BJ42(DDR3L_CH0_DQSP5_LPDDR3_CH0_DQSP) U25.C7(DQSU)
M_A_DQS6: U9.C7(DQSU) U21.BB35(DDR3L_CH0_DQSP6_LPDDR3_CH0_DQSP)
M_A_DQS7: U21.BG36(DDR3L_CH0_DQSP7_LPDDR3_CH0_DQSP) U25.F3(DQSL)
M_A_DQS#0: U21.BC62(DDR3L_CH0_DQSN0_LPDDR3_CH0_DQSN) U24.G3(D\Q\S\L\)
M_A_DQS#1: U21.AT58(DDR3L_CH0_DQSN1_LPDDR3_CH0_DQSN) U24.B7(D\Q\S\U\)
M_A_DQS#2: U8.G3(D\Q\S\L\) U21.BB58(DDR3L_CH0_DQSN2_LPDDR3_CH0_DQSN)
M_A_DQS#3: U8.B7(D\Q\S\U\) U21.BB52(DDR3L_CH0_DQSN3_LPDDR3_CH0_DQSN)
M_A_DQS#4: U9.G3(D\Q\S\L\) U21.AW39(DDR3L_CH0_DQSN4_LPDDR3_CH0_DQSN)
M_A_DQS#5: U21.BG42(DDR3L_CH0_DQSN5_LPDDR3_CH0_DQSN) U25.B7(D\Q\S\U\)
M_A_DQS#6: U9.B7(D\Q\S\U\) U21.BD35(DDR3L_CH0_DQSN6_LPDDR3_CH0_DQSN)
M_A_DQS#7: U21.BH35(DDR3L_CH0_DQSN7_LPDDR3_CH0_DQSN) U25.G3(D\Q\S\L\)
M_A_ODT0: R152.2 U8.K1(ODT) U9.K1(ODT) U24.K1(ODT) U25.K1(ODT)
M_A_RAS#: R423.2 U8.J3(R\A\S\) U9.J3(R\A\S\) U21.BG47(DDR3L_CH0_RAS_N_LPDDR3_CH0_CAB3) U24.J3(R\A\S\) U25.J3(R\A\S\)
M_A_WE#: R429.2 U8.L3(W\E\) U9.L3(W\E\) U21.BG48(DDR3L_CH0_WE_N_LPDDR3_CH0_CAB4) U24.L3(W\E\) U25.L3(W\E\)
M_A_ZQ1: R414.2 U24.L8(ZQ)
M_A_ZQ2: R149.2 U8.L8(ZQ)
M_A_ZQ3: R412.2 U25.L8(ZQ)
M_A_ZQ4: R162.2 U9.L8(ZQ)
M_B_A0: R439.2 U10.N3(A0) U11.N3(A0) U21.BG9(DDR3L_CH1_MA0_LPDDR3_CH1_CAB7) U26.N3(A0) U27.N3(A0)
M_B_A1: R200.2 U10.P7(A1) U11.P7(A1) U21.BG10(DDR3L_CH1_MA1_LPDDR3_CH1_CAB9) U26.P7(A1) U27.P7(A1)
M_B_A2: R201.2 U10.P3(A2) U11.P3(A2) U21.BH9(DDR3L_CH1_MA2_LPDDR3_CH1_CAB5) U26.P3(A2) U27.P3(A2)
M_B_A3: R436.2 U10.N2(A3) U11.N2(A3) U21.BD16(DDR3L_CH1_MA3_LPDDR3_NC) U26.N2(A3) U27.N2(A3)
M_B_A4: R197.2 U10.P8(A4) U11.P8(A4) U21.BB16(DDR3L_CH1_MA4_LPDDR3_NC) U26.P8(A4) U27.P8(A4)
M_B_A5: R196.2 U10.P2(A5) U11.P2(A5) U21.BG11(DDR3L_CH1_MA5_LPDDR3_CH1_CAA2) U26.P2(A5) U27.P2(A5)
M_B_A6: R195.2 U10.R8(A6) U11.R8(A6) U21.BJ12(DDR3L_CH1_MA6_LPDDR3_CH1_CAA0) U26.R8(A6) U27.R8(A6)
M_B_A7: R194.2 U10.R2(A7) U11.R2(A7) U21.BG14(DDR3L_CH1_MA7_LPDDR3_CH1_CAA3) U26.R2(A7) U27.R2(A7)
M_B_A8: R437.2 U10.T8(A8) U11.T8(A8) U21.BG12(DDR3L_CH1_MA8_LPDDR3_CH1_CAA1) U26.T8(A8) U27.T8(A8)
M_B_A9: R192.2 U10.R3(A9) U11.R3(A9) U21.BH11(DDR3L_CH1_MA9_LPDDR3_CH1_CAA4) U26.R3(A9) U27.R3(A9)
M_B_A10: R442.2 U10.L7(A10/AP) U11.L7(A10/AP) U21.BG7(DDR3L_CH1_MA10_LPDDR3_CH1_CAB6) U26.L7(A10/AP) U27.L7(A10/AP)
M_B_A11: R191.2 U10.R7(A11) U11.R7(A11) U21.BH13(DDR3L_CH1_MA11_LPDDR3_CH1_CAA6) U26.R7(A11) U27.R7(A11)
M_B_A12: R190.2 U10.N7(A12/B\C\) U11.N7(A12/B\C\) U21.BG13(DDR3L_CH1_MA12_LPDDR3_CH1_CAA5) U26.N7(A12/B\C\) U27.N7(A12/B\C\)
M_B_A13: R198.2 U10.T3(A13) U11.T3(A13) U21.BH3(DDR3L_CH1_MA13_LPDDR3_CH1_CAB0) U26.T3(A13) U27.T3(A13)
M_B_A14: R193.2 U10.T7(A14) U11.T7(A14) U21.BG15(DDR3L_CH1_MA14_LPDDR3_CH1_CAA8) U26.T7(A14) U27.T7(A14)
M_B_A15: R433.2 U10.M7(A15/NC) U11.M7(A15/NC) U21.BG16(DDR3L_CH1_MA15_LPDDR3_CH1_CAA9) U26.M7(A15/NC) U27.M7(A15/NC)
M_B_BS#0: R440.2 U10.M2(BA0) U11.M2(BA0) U21.BH6(DDR3L_CH1_BA0_LPDDR3_CH1_CAB2) U26.M2(BA0) U27.M2(BA0)
M_B_BS#1: R199.2 U10.N8(BA1) U11.N8(BA1) U21.BG8(DDR3L_CH1_BA1_LPDDR3_CH1_CAB8) U26.N8(BA1) U27.N8(BA1)
M_B_BS#2: R434.2 U10.M3(BA2) U11.M3(BA2) U21.BH15(DDR3L_CH1_BA2_LPDDR3_CH1_CAA7) U26.M3(BA2) U27.M3(BA2)
M_B_CAS#: R438.2 U10.K3(C\A\S\) U11.K3(C\A\S\) U21.BH4(DDR3L_CH1_CAS_N_LPDDR3_CH1_CAB1) U26.K3(C\A\S\) U27.K3(C\A\S\)
M_B_CKE0: R431.2 U10.K9(CKE) U11.K9(CKE) U21.BG18(DDR3L_CH1_CKE0_LPDDR3_CH1_CKE0A) U26.K9(CKE) U27.K9(CKE)
M_B_CLK0: R156.2 U10.J7(CK) U11.J7(CK) U21.BD19(DDR3L_CH1_CLKP0_LPDDR3_CH1_CLKP) U26.J7(CK) U27.J7(CK)
M_B_CLK0#: R156.1 U10.K7(C\K\) U11.K7(C\K\) U21.BE19(DDR3L_CH1_CLKN0_LPDDR3_CH1_CLKN) U26.K7(C\K\) U27.K7(C\K\)
M_B_CS#0: R432.2 U10.L2(C\S\) U11.L2(C\S\) U21.BD17(DDR3L_CH1_CS0_N_LPDDR3_CH1_CS0A) U26.L2(C\S\) U27.L2(C\S\)
M_B_DQ0: U21.BJ26(DDR3L_CH1_DQ0_LPDDR3_CH1_DQA0) U26.E3(DQL0/DQ0)
M_B_DQ1: U21.BG30(DDR3L_CH1_DQ1_LPDDR3_CH1_DQA1) U26.H3(DQL4/DQ4)
M_B_DQ2: U21.BH31(DDR3L_CH1_DQ2_LPDDR3_CH1_DQA2) U26.G2(DQL6/DQ6)
M_B_DQ3: U21.BG31(DDR3L_CH1_DQ3_LPDDR3_CH1_DQA3) U26.H8(DQL5/DQ5)
M_B_DQ4: U21.BH27(DDR3L_CH1_DQ4_LPDDR3_CH1_DQA4) U26.F7(DQL1/DQ1)
M_B_DQ5: U21.BG27(DDR3L_CH1_DQ5_LPDDR3_CH1_DQA5) U26.F2(DQL2/DQ2)
M_B_DQ6: U21.BG26(DDR3L_CH1_DQ6_LPDDR3_CH1_DQA6) U26.F8(DQL3/DQ3)
M_B_DQ7: U21.BJ30(DDR3L_CH1_DQ7_LPDDR3_CH1_DQA7) U26.H7(DQL7/DQ7)
M_B_DQ8: U10.H7(DQL7/DQ7) U21.BA30(DDR3L_CH1_DQ8_LPDDR3_CH1_DQA8)
M_B_DQ9: U10.H3(DQL4/DQ4) U21.BB30(DDR3L_CH1_DQ9_LPDDR3_CH1_DQA9)
M_B_DQ10: U10.G2(DQL6/DQ6) U21.BE30(DDR3L_CH1_DQ10_LPDDR3_CH1_DQA10)
M_B_DQ11: U10.H8(DQL5/DQ5) U21.BD30(DDR3L_CH1_DQ11_LPDDR3_CH1_DQA11)
M_B_DQ12: U10.E3(DQL0/DQ0) U21.BE25(DDR3L_CH1_DQ12_LPDDR3_CH1_DQA12)
M_B_DQ13: U10.F2(DQL2/DQ2) U21.BB27(DDR3L_CH1_DQ13_LPDDR3_CH1_DQA13)
M_B_DQ14: U10.F8(DQL3/DQ3) U21.BD25(DDR3L_CH1_DQ14_LPDDR3_CH1_DQA14)
M_B_DQ15: U10.F7(DQL1/DQ1) U21.BD27(DDR3L_CH1_DQ15_LPDDR3_CH1_DQA15)
M_B_DQ16: U21.BG24(DDR3L_CH1_DQ16_LPDDR3_CH1_DQA16) U26.D7(DQU0/DQ8)
M_B_DQ17: U21.BJ20(DDR3L_CH1_DQ17_LPDDR3_CH1_DQA17) U26.A2(DQU5/DQ13)
M_B_DQ18: U21.BH23(DDR3L_CH1_DQ18_LPDDR3_CH1_DQA18) U26.A7(DQU4/DQ12)
M_B_DQ19: U21.BJ24(DDR3L_CH1_DQ19_LPDDR3_CH1_DQA19) U26.B8(DQU6/DQ14)
M_B_DQ20: U21.BG20(DDR3L_CH1_DQ20_LPDDR3_CH1_DQA20) U26.A3(DQU7/DQ15)
M_B_DQ21: U21.BG21(DDR3L_CH1_DQ21_LPDDR3_CH1_DQA21) U26.C2(DQU3/DQ11)
M_B_DQ22: U21.BH19(DDR3L_CH1_DQ22_LPDDR3_CH1_DQA22) U26.C3(DQU1/DQ9)
M_B_DQ23: U21.BG25(DDR3L_CH1_DQ23_LPDDR3_CH1_DQA23) U26.C8(DQU2/DQ10)
M_B_DQ24: U10.A3(DQU7/DQ15) U21.AT27(DDR3L_CH1_DQ24_LPDDR3_CH1_DQA24)
M_B_DQ25: U10.C2(DQU3/DQ11) U21.AW29(DDR3L_CH1_DQ25_LPDDR3_CH1_DQA25)
M_B_DQ26: U10.A7(DQU4/DQ12) U21.AR27(DDR3L_CH1_DQ26_LPDDR3_CH1_DQA26)
M_B_DQ27: U10.D7(DQU0/DQ8) U21.AT23(DDR3L_CH1_DQ27_LPDDR3_CH1_DQA27)
M_B_DQ28: U10.C3(DQU1/DQ9) U21.AV27(DDR3L_CH1_DQ28_LPDDR3_CH1_DQA28)
M_B_DQ29: U10.B8(DQU6/DQ14) U21.AR25(DDR3L_CH1_DQ29_LPDDR3_CH1_DQA29)
M_B_DQ30: U10.C8(DQU2/DQ10) U21.AR23(DDR3L_CH1_DQ30_LPDDR3_CH1_DQA30)
M_B_DQ31: U10.A2(DQU5/DQ13) U21.AW27(DDR3L_CH1_DQ31_LPDDR3_CH1_DQA31)
M_B_DQ32: U21.BF6(DDR3L_CH1_DQ32_LPDDR3_CH1_DQB0) U27.A2(DQU5/DQ13)
