# Allegro board Quanta Z8P DA0Z8PMB8D0 REV D - BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
VSTBY_FSPI: length 233.6
  TOP w0.508: v1(45.12,64.22) 44.14,63.24 44.14,55.89 42.02,53.77 42.02,49.87 44.18,47.71 44.18,42.45 43.74,42.01 v1(43.44,42.01) ; U1.8 C5.1 71.89,117.89 v1(72.11,117.67) ; R205.1 142.35,38.69 v1(141,40.04)
  IN2 w0.508: v1(43.44,42.01) 43.1,41.68 43.1,39.69 49.89,32.9 100.24,32.9 101.38,34.04 107.37,34.04 109.87,36.54 113.78,36.54 114.29,37.05 116.2,37.05 121.54,42.4 128.25,42.4 128.77,41.88 133.02,41.88 133.33,41.56 v1(133.33,41.27) 133.34,41.27 139.78,41.27 v1(141,40.04) v1(145.4,40.04) ; v1(72.11,117.67) 71.28,117.67 70.83,117.22 70.83,107.56 69.79,106.51 69.79,103.88 v1(69.31,103.4) 68.41,102.51 v1(66.88,102.51) 64.36,102.51 63.99,102.88 60.68,102.88 60.01,102.21 55.1,102.21 52.9,100.01 52.9,92.85 51.9,91.84 51.9,84.02 50.02,82.14 50.02,74.37 49.17,73.52 49.17,69.1 45.12,65.05 v1(45.12,64.22)
  BOTTOM w0.508: v1(69.31,103.4) 69.17,103.26 R326.2 ; U28.8 134.84,41.74 134.72,41.86 C380.1 R417.2 133.88,40.6 133.33,41.15 v1(133.33,41.27) ; R448.2 150.48,38.56 149.85,39.2 R445.2 v1(145.4,40.04) R415.1 ; R352.2 R354.2 68.91,99.78 66.88,101.81 v1(66.88,102.51)
VSTBY_FSPI_R: length 5.4
  TOP w0.14: U16.106 141.88,33.01 142.46,33.59 C206.1 141.97,34.85 141.97,36.24 142.35,36.63 R205.2
WRST#: length 15.7
  TOP w0.127: U16.14 132.2,25.26 132.84,25.9 133.55,25.9 v1(133.97,26.32)
  BOTTOM w0.127: v1(129.55,34.24) 128.99,33.69 128.99,33.18 129.21,32.96 Q33.6
  BOTTOM w0.14: v1(133.97,26.32) 133.97,27.17 C416.1 R462.1 131.91,27.6 131.76,27.45 D24.2 131.13,28.47 130.81,28.79 130.81,29.36 130.68,29.48 130.68,30.81 130.83,30.96 130.83,32.71 130.58,32.96 Q33.6
XDP_PRDY#: length 10.3
  BOTTOM w0.102: U21.C21 95.3,97.3 95.59,97.59 95.59,97.84 95.48,97.94 95.48,98.84 95.79,99.15 96.69,99.15 98.28,100.75 98.28,101.45 98.99,102.16 100.44,102.16 v1(100.82,102.54) 101.2,102.92 101.2,102.98
  BOTTOM w0.127: R306.1 101.2,102.98
XDP_PREQ#: length 10.1
  BOTTOM w0.102: U21.C20 95.91,97.49 95.91,97.81 96.04,97.94 96.04,98.19 96.39,98.54 96.39,98.57 98.49,100.67 98.49,101.37 99.08,101.96 101.53,101.96 v1(102.12,102.54) 102.16,102.59 102.16,102.98
  BOTTOM w0.127: R307.1 102.16,102.98
XDP_TCK: length 5.4
  BOTTOM w0.102: U21.B23 94.35,97.73 94.35,98.36 94.67,98.68 94.67,99.18 95.45,99.97 96.32,99.97 97.27,100.91 R335.1
XDP_TDI: length 9.2
  BOTTOM w0.102: U21.C22 94.95,97.45 94.95,97.78 95.28,98.11 95.28,98.93 95.71,99.36 96.6,99.36 98.08,100.83 98.08,101.55 99.09,102.57 v1(99.55,102.57) 99.83,102.57 100.24,102.98
  BOTTOM w0.127: R305.1 100.24,102.98
XDP_TDO: length 7.6
  BOTTOM w0.102: U21.A22 95.08,98.36 95.08,99.01 95.62,99.56 96.52,99.56 97.88,100.92 97.88,101.73 98.9,102.75 98.9,102.98
  BOTTOM w0.14: R304.1 98.9,102.98
XDP_TMS: length 8.7
  BOTTOM w0.102: 98.32,102.98 98.32,102.78 v1(98.08,102.54) 97.67,102.14 97.67,101 96.43,99.76 95.54,99.76 94.87,99.1 94.87,98.59 94.56,98.27 94.56,97.94 94.66,97.84 94.66,97.59 94.37,97.3 U21.C23
  BOTTOM w0.127: R303.1 98.32,102.98
XDP_TRST#: length 9.5
  BOTTOM w0.102: 96.5,102.98 96.5,102.43 96.87,102.06 96.87,100.91 96.13,100.17 95.33,100.17 94.33,99.17 93.21,99.17 92.98,98.94 92.98,98.56 93.26,98.27 93.26,97.95 93.15,97.84 93.15,97.59 93.4,97.34 U21.C24
  BOTTOM w0.127: 96.5,102.98 R322.1
XTAL192_IN: length 24.5
  IN3 w0.127: v1(100.97,100.71) 100.29,101.38 100.29,102.38 100.44,102.53 100.85,102.53 101,102.68 101,102.89 100.85,103.04 100.44,103.04 100.29,103.19 100.29,103.4 100.44,103.55 100.83,103.55 100.98,103.7 100.98,103.91 100.83,104.05 100.44,104.05 100.29,104.2 v1(100.29,104.97)
  BOTTOM w0.102: U21.R27 92.63,91.23 92.98,91.59 93.55,91.59 93.78,91.82 93.78,92.24 94.12,92.58 94.12,92.86 94.22,92.96 94.51,92.96 95.32,93.77 95.47,93.77 96.15,94.46 96.44,94.46 96.65,94.66 96.65,95.06 96.75,95.17 97.36,95.17 97.52,95.33 97.52,95.63 97.7,95.8 97.9,95.8 98.13,96.04 98.13,96.51 98.84,97.22 98.84,97.47 98.72,97.59 98.72,97.84 98.99,98.12 98.99,99.14 100.17,100.32 100.58,100.32 v1(100.97,100.71)
  BOTTOM w0.127: Y3.1 100.54,107.19 C310.2 100.2,106.24 R301.2 100.2,105.07 v1(100.29,104.97)
XTAL192_OUT: length 24.5
  IN3 w0.127: v1(99.45,104.97) 99.67,104.76 v1(99.67,100.77)
  BOTTOM w0.102: U21.P29 91.96,92.3 92.62,92.3 92.86,92.06 93.16,92.06 93.43,92.34 93.59,92.34 93.83,92.59 93.83,93.5 94.03,93.69 94.53,93.69 95.23,94.39 95.62,94.39 95.83,94.6 95.83,95.47 96.17,95.8 97.23,95.8 97.52,96.1 97.52,96.34 97.71,96.53 97.71,97.01 97.97,97.26 98.04,97.26 98.37,97.59 98.37,97.85 98.24,97.98 98.24,98.25 98.72,98.73 98.72,99.19 99.67,100.15 v1(99.67,100.77)
  BOTTOM w0.127: Y3.3 99.75,109.52 99.89,109.38 99.89,106.89 99.6,106.59 C309.2 99.6,105.8 R301.1 99.42,105.25 99.45,105.21 v1(99.45,104.97)
N16788300: length 2.7
  TOP w0.14: U16.12 130.68,26.06 129.98,25.36 v1(129.98,25.23) C252.1
N16788484: length 4.6
  TOP w0.127: U16.66 147.79,18.46 147.83,18.42 147.91,18.42 147.94,18.39 147.94,18.37 148.07,18.24 148.07,18.18 149.11,17.14 v1(149.11,17.02) 148.73,16.64 C276.2 R269.1
N16788623: length 5.9
  TOP w0.127: v1(146.52,36.71) 146.08,36.27 C194.1
  TOP w0.14: U16.98 145.08,32.87 145.53,33.32 R214.1 145.11,34.78 145.11,35.85 C194.1
N16789334: length 2
  TOP w0.14: U16.126 133.88,34 TP17.1
N17002655: length 4.7
  TOP w0.203: 203.62,31.02 203.62,30.64 203.29,30.31 U15.39
  TOP w0.254: C223.2 206.45,31.27 204.43,31.27 v1(204.3,31.4) 204,31.4 203.62,31.02
N17002661: length 4.4
  TOP w0.14: U15.37 204.09,29.89 204.33,30.13 204.81,30.13 v1(204.98,30.29) 205.21,30.53 207.45,30.53 C231.1
N17002676: length 2.4
  TOP w0.203: C237.2 v1(206.34,28.36) 205.92,28.36 205.56,28 U15.34
N17002678: length 5.7
  TOP w0.203: U15.19 202.09,22.85 202.42,22.52 202.42,21.67 202.71,21.38 v1(204.71,21.38) v1(205.39,21.38)
  BOTTOM w0.203: C443.1 205.26,21.25 v1(205.39,21.38)
N17002722: length 2.1
  TOP w0.14: U15.48 199.27,30.12 197.89,30.12 TP19.1
N17002952: length 2.3
  TOP w0.14: C250.1 196.97,25.51 v1(197.63,26.16) 197.86,26.4 U15.7
N17003087: length 10.1
  TOP w0.14: v1(195.26,22.39) 195.03,22.61 v1(194.55,22.61) 194.25,22.61 193.75,22.12 R255.2
  BOTTOM w0.127: D23.1 D25.1 194.66,26.87 194.66,26.55 194.32,26.21 194.32,25.23 194.6,24.96 194.97,24.96 195.17,24.76 195.17,22.47 v1(195.26,22.39)
N17003129: length 3.3
  TOP w0.203: U15.35 205.53,28.4 205.95,28.82 207.39,28.82 C231.2
N17004316: length 3.4
  BOTTOM w0.127: Q32.3 194.89,35.01 v1(195.13,35.26)
  BOTTOM w0.508: D21.1 196.17,34.46 195.84,34.13 Q32.3
N17045098: length 5.3
  TOP w0.14: R208.1 131.59,35.64 131.59,34.74 132.05,34.27 C207.1 132.03,34.21 v1(132.03,33.08) 132.85,33.08 133.08,32.85 U16.128
N19171544: length 8.8
  TOP w0.127: R204.1 136.07,38.42 135.24,39.25 v1(135.24,39.68)
  TOP w0.203: R204.1 136.38,37.84 136.38,37.48 D6.2 136.38,36.85 136.38,36.5 C195.1 136.07,35.64 137.08,34.63 137.08,33.95 137.08,33.95 U16.118
N19520551: length 2.4
  TOP w0.508: v1(153.43,22.61) 153.68,22.61 R253.1
  BOTTOM w0.457: v1(153.43,22.61) 153.43,22.59 153.4,22.56 CN14.27
N20280006:
  vias: v1(33.03,74.86)
N20280012: length 8
  TOP w0.127: v1(146.28,39.7) PR43.2
  TOP w0.254: PR43.2 146.28,41.79 v1(146.01,42.07)
  BOTTOM w0.254: v1(146.01,42.07) 146.94,42.07 148.14,43.26 150,43.26 150.24,43.5 PQ15.3
N22098686: length 3.9
  BOTTOM w0.14: Q27.2 78.73,104.75 78.88,104.59 79.21,104.59 79.38,104.76 Q27.3 79.38,106.43 79.34,106.47 R297.1
N22098968: length 3.7
  BOTTOM w0.14: Q26.2 76.44,104.82 76.57,104.69 76.98,104.69 77.09,104.8 Q26.3 77.09,107.06 R299.1
N22122752: length 20.3
  TOP w0.305: v1(22.58,68.44) 22.23,68.79 R122.2
  TOP w0.381: R143.2 22.29,61.13 22.35,61.08 v1(22.39,61.08) 22.81,61.08 23.15,60.74 v1(23.15,60.17) 20.61,57.63 Q13.3 ; v1(22.39,62.34) R139.2 R138.2 ; R133.2 R134.2 v1(22.39,64.5) ; v1(22.39,66.67) R129.2 R126.2
  IN3 w0.381: v1(22.39,61.08) v1(22.39,62.34) v1(22.39,64.5) v1(22.39,66.67) 22.39,68.26 v1(22.58,68.44)
N22131520: length 16.2
  TOP w0.508: Q14.2 5.08,56.54 11.13,56.54 11.95,57.36 C138.1 13.55,57.36 14.75,56.16 v1(16.22,56.16) 16.22,55.86 17.02,55.05 R151.1
N22234733: length 10.7
  TOP w0.127: v1(81.11,85.84) 79.93,87.03 v1(79.18,87.03) 76.57,87.03 75.97,87.62 72.55,87.62 C58.1
  BOTTOM w0.102: v1(81.11,85.84) 81.47,86.2 U21.AG51
N22534967: length 1.7
  TOP w0.14: v1(86.44,94.42) 85.46,94.42 TP1.1
  BOTTOM w0.102: v1(86.44,94.42) 86.1,94.08 U21.J41
N22534977: length 1.8
  TOP w0.14: TP2.1 85.41,93.09 85.43,93.09 v1(86.45,93.09)
  BOTTOM w0.102: v1(86.45,93.09) 86.45,93.03 86.08,92.65 U21.M41
N22543099: length 2
  TOP w0.14: TP9.1 80.41,83.38 v1(81.11,84.08)
  BOTTOM w0.102: U21.AM51 81.47,83.72 v1(81.11,84.08)
N22543112: length 1.2
  TOP w0.14: TP7.1 82.91,84.47 v1(82.45,84.01)
  BOTTOM w0.102: U21.AM49 82.18,83.74 v1(82.45,84.01)
N22543128: length 2.6
  TOP w0.127: TP8.1 77.33,83.04 v1(78.25,83.96)
  BOTTOM w0.14: v1(78.25,83.96) 78.25,83.91 78.58,83.57 U21.AM57
N22543144: length 2.1
  TOP w0.127: TP10.1 78.32,83.42 78.44,83.42 v1(79.01,83.99)
  BOTTOM w0.14: U21.AM55 79.33,83.66 v1(79.01,83.99)
N22563616: length 3.9
  TOP w0.127: R267.1 108.73,16.7 v1(108.85,16.82)
  TOP w0.254: R267.1 Q20.3 108.05,18.36 107.87,18.54 107.51,18.54 107.4,18.43 Q20.2
N22799421: length 8.4
  TOP w0.14: U16.48 139.08,15.55 138.94,15.41 135.38,15.41 135.06,15.09 131.96,15.09 TP28.1
N22836684: length 1.1
  BOTTOM w0.127: PR148.2 v1(126.22,102.54)
N22836710:
  vias: v1(115.99,108.59)
N22836724: length 2.6
  BOTTOM w0.127: JP6.2 v1(127.67,101.93)
N22839470: length 4.5
  TOP w0.127: v1(118.47,121.54) PR33.1
  TOP w0.254: v1(117.43,120.78) 117.87,120.78 118.05,120.6 PR33.1
  BOTTOM w0.254: v1(117.43,120.78) 117.72,120.49 PR133.2 PR131.2
N22839532: length 6.5
  TOP w0.254: PC15.2 PR26.2 106.52,122.63 PC19.2 106.16,121.9 106.06,121.8 v1(105.98,121.8) 105.4,122.37 v1(105.4,122.38) PR30.2
  BOTTOM w0.254: PR30.2 v1(105.4,122.38) 105.91,122.38 PC19.2
N22839622: length 2.5
  TOP w0.254: PC15.1 108.07,125.02 108.43,125.38 v1(109.1,125.38) 109.2,125.29 PR23.2
N22839806: length 1.1
  BOTTOM w0.254: PR120.2 PC96.1
N22839827: length 1.1
  BOTTOM w0.254: PR118.2 PC94.1
N22841416:
  vias: v1(85.38,128.66)
N22841457:
  vias: v1(97.83,133.66)
N22841539:
  vias: v1(68.82,132.03)
N22841632: length 3.2
  BOTTOM w0.229: v1(94.27,137.47) 93.61,137.47 PR84.1 93.47,137.13 94.45,136.14 PU4.3
N22841634: length 7.4
  TOP w0.254: PR1.2 99.53,137.1 99.71,136.92 100.62,136.92 100.96,136.58 100.96,136.07 v1(100.77,135.88)
  BOTTOM w0.229: PC67.2 98.29,136.14 PU4.6
  BOTTOM w0.254: PC67.2 98.86,136.39 99.38,135.88 v1(100.77,135.88)
N22860674: length 50.4
  TOP w0.254: v1(117.77,131.68) 117.74,131.65 117.03,131.65 PR6.1
  IN1 w0.254: v1(117.77,131.68) 117.77,131.96 114.05,135.68 103.48,135.68 99.87,139.29 88.24,139.29 85.31,136.36 85.31,129.45 83.85,127.98 82.4,127.98 v1(81.89,128.49)
  BOTTOM w0.254: PR110.1 v1(81.89,128.49)
N22860692: length 2.6
  BOTTOM w0.254: PR101.1 117.94,130.26 118.3,129.9 v1(118.3,129.67) 118.3,129.24 118.05,129 PC87.1
N22861223: length 8.7
  TOP w0.254: v1(114.51,132.19) 114.49,132.18 113.09,132.18 112.84,131.93 PC3.2 113.2,131.04 113.4,130.84 113.4,130.51 113.65,130.26 PC4.1 PR12.2 PR13.2
  BOTTOM w0.254: v1(114.51,132.19) 114.62,132.19 114.77,132.34 PR95.2 115.16,131.98 115.04,131.86 PC83.2
N22861277: length 1.3
  BOTTOM w0.254: PR107.2 PC83.1
N22861281: length 0.8
  BOTTOM w0.254: TP29.1 PR97.1
N22861301: length 1.3
  BOTTOM w0.254: PR106.2 PC82.1
N22861313: length 1.3
  BOTTOM w0.254: PC81.1 PR105.2
N22885414: length 1.4
  BOTTOM w0.203: PU6.8 PR132.1
N22946208:
  vias: v1(91.78,137.24)
N22946214: length 2.1
  BOTTOM w0.229: PU4.2 94.6,135.64
  BOTTOM w0.508: 94.6,135.64 v1(94.27,135.64) 93.74,135.64 PR86.1
N22946324: length 7.3
  IN1 w0.762: v2(94.45,134.75) 94.45,131.07 v2(91.91,128.53)
  vias: v1(95.13,134.32)
N22949643: length 4
  TOP w0.254: v1(81.68,137.81) PR2.2
  BOTTOM w0.127: v1(81.68,138.49) v1(81.68,137.81)
  BOTTOM w0.203: PU3.6 81.02,136.35 PR2.2
  BOTTOM w0.254: v1(81.68,137.81) PR2.2
N22949653: length 2.5
  BOTTOM w0.127: v1(76.83,137.69) PR85.1
  BOTTOM w0.229: PR85.1 77.22,136.47 77.86,136.47 77.98,136.35 PU3.3
N22950763: length 1
  TOP w0.127: PC14.1 v1(75.35,126.33)
N22950767:
  vias: v1(77.79,134.07)
N22950773: length 2
  BOTTOM w0.203: PU3.2 77.88,135.85
  BOTTOM w0.254: 77.88,135.85 77.84,135.9 v1(77.45,135.9) 76.86,135.9 PR92.1
N22950844: length 7
  IN1 w0.762: v2(74.18,129.58) 74.18,130.59 77.56,133.96 v2(77.56,135.13)
  vias: v1(73.85,130.21)
N22956619: length 3.8
  TOP w0.508: PQ3.3 43.37,88.09 43.09,87.81 v1(42.71,87.81) 42.31,88.21 PR39.2
N23041304: length 6.3
  TOP w0.127: TP6.1 73.82,85.37 75.43,85.37 75.73,85.06 76.48,85.06 76.76,85.34 77.74,85.34 v1(78.27,85.87)
  BOTTOM w0.102: U21.AG58 78.27,85.92 v1(78.27,85.87)
N23063584:
  vias: v1(52.69,117.81)
N23063683: length 1.9
  TOP w0.127: v1(55.74,130.99) PR10.1
  TOP w0.254: PC8.2 56.79,130.16 PR10.1
N23086343: length 6.4
  BOTTOM w0.102: U21.A26 92.71,98.38 92.71,98.96 93.13,99.38 94.25,99.38 95.24,100.37 95.8,100.37 96.46,101.03 TP32.1
N23103470: length 45.3
  TOP w0.254: U14.14 158.72,31.21 159.12,30.82 159.12,29.95 C234.1
  TOP w0.305: U14.1 C196.2 ; U14.22 162.52,35.12 C201.1 ; C217.1 U14.8
  TOP w0.381: C201.1 162.61,34.82 162.8,34.63 v1(162.8,34.43)
  TOP w0.508: v1(151.95,37.58) 152.29,37.91 152.95,37.91 153.41,37.45 C190.2 C196.2 ; C217.1 C222.1 R236.1 v1(154.32,30.43) ; v1(158.49,30.36) 158.49,29.88 158.69,29.68 C234.1
  IN1 w0.508: v1(162.8,34.43) 162.8,34.85 162.53,35.12 161.74,35.12 158.38,38.48 152.86,38.48 v1(151.95,37.58) 151.46,37.58 150.2,36.32 150.2,35.19 150.9,34.48 150.9,32.04 152.51,30.43 v1(154.32,30.43) 155.33,30.43 156.36,31.46 157.38,31.46 v1(158.49,30.36)
N23135271: length 7.3
  BOTTOM w0.127: Q31.3 123.56,34.7 v1(123.46,34.6)
  BOTTOM w0.508: Q31.3 124.55,33.08 124.59,33.04 123.85,32.3 SW2.4 SW2.3
N23202325: length 4
  BOTTOM w0.254: R457.1 R455.1 132.02,33.81 v1(131.33,33.81) 131.12,34.02 131.12,34.85 130.84,35.13 R454.1
N23202350: length 7.5
  BOTTOM w0.127: C402.2 132.87,30.72 v1(132.59,30.72)
  BOTTOM w0.254: Q33.2 131.3,32.31 131.29,32.3 131.28,32.3 131.15,32.17 131.15,31.81 131.21,31.75 131.29,31.66 Q33.3 133.04,31.66 133.11,31.6 133.18,31.6 C402.2 133.84,31.31 133.97,31.45 133.97,32.69 R457.2
N23458866: length 2.7
  TOP w0.14: TP14.1 31.41,40.34 30.38,39.31 U13.37
N23458888: length 3.6
  TOP w0.14: TP13.1 30.85,40.83 29.18,39.17 U13.40
N23458910: length 2
  TOP w0.14: v1(28.14,39.55) 27.98,39.39 U13.43
  BOTTOM w0.14: TP40.1 v1(28.14,39.55)
N23458912: length 3.9
  TOP w0.14: U13.38 29.98,39.25 32.19,41.46 TP12.1
N25137104: length 13.1
  BOTTOM w0.102: 70.32,83.4 72.12,83.4 72.3,83.57 72.88,83.57 74.74,85.43 75.77,85.43 U21.AH62
  BOTTOM w0.14: 70.32,83.4 v1(69.98,83.4) 69.73,83.4 69.25,83.87 68.17,83.87 67.86,83.56 66.07,83.56 65.8,83.84 65.8,85.1 65.91,85.21 R391.2
N25421357: length 35.2
  TOP w0.508: PQ6.4 v1(229.56,38.31)
  IN1 w0.508: v1(229.56,38.31) 226.45,38.31 224.91,36.78 221.92,36.78 218.92,33.77 214.36,33.77 213.49,32.9 208.79,32.9 207.38,34.31 203.85,34.31 200.6,37.56 v1(199.52,37.56)
N25421372: length 5.9
  TOP w0.508: PR49.2 70.63,30.17 PR51.1 71.48,28.53 v1(71.48,26.18)
  BOTTOM w0.508: PQ17.4 v1(71.48,26.18)
N25421377: length 4.2
  BOTTOM w0.127: v1(201.15,40.52) 201,40.36 PQ16.2
  BOTTOM w0.381: PQ16.1 201.95,38.32 201.74,38.11 201.2,38.11 201,38.31 PQ16.2
N25421382: length 155.1
  TOP w0.508: v1(75.74,29.73) 75.74,31 74.88,31.85 PQ7.2
  IN1 w0.381: v1(178.8,30.8) 177.44,30.8 v1(172.3,25.66)
  IN2 w0.508: v1(75.74,29.73) 77.25,31.25 101.11,31.25 102.25,32.38 108.07,32.38 110.57,34.88 113.91,34.88 114.06,34.74 115.25,34.74 115.91,35.4 116.88,35.4 117.48,36 119.53,36 120.8,34.72 123.91,34.72 126.01,32.63 126.57,32.63 127.78,31.42 127.78,30.85 129.08,29.55 131.21,29.55 132.39,28.36 134.24,28.36 134.92,29.05 136.23,29.05 136.91,28.36 142.01,28.36 144.04,26.34 148.06,26.34 149.09,25.3 153.53,25.3 154.16,24.67 154.72,24.67 155.89,23.5 165.35,23.5 167.51,25.66 v1(172.3,25.66)
  BOTTOM w0.381: v1(178.8,30.8) 178.8,36.12 182.21,39.53 188.96,39.53 192.51,35.98 196.5,35.98 197.45,35.03 200.23,35.03 200.36,34.9 PR189.1 PQ16.5
N25421386: length 3.4
  TOP w0.152: PR83.1 62.35,15.77 62.35,18.02 62.25,18.12 PR78.1
  vias: v1(60.03,18.47) v2(59.02,16.95) v2(59.33,16.01) v2(59.6,17.56) v2(59.85,16.61) v2(59.9,15.38) v2(60.32,16.01) v2(60.36,17.25) v2(60.77,16.62) v2(60.77,15.38)
N25421433: length 1.3
  TOP w0.127: PR69.2 v1(55.32,19.51)
N25421444: length 3.3
  TOP w0.14: PR75.1 78.52,20.11 78.31,20.11 v1(77.57,20.86)
  BOTTOM w0.127: v1(77.57,20.86) 77.59,20.88 PJ5.3
N25421470: length 3.3
  TOP w0.14: PR44.1 219.87,34.3 219.74,34.16 219.74,32.38 PR46.2
  vias: v1(221.45,30.51)
N25421477: length 2.8
  TOP w0.14: v1(75.31,20.68) 74.92,20.29 PR74.1
  BOTTOM w0.14: v1(75.31,20.68) 75.59,20.96 PJ5.4
N25421489: length 4.3
  TOP w0.127: PR72.2 v1(49.64,19.24)
  TOP w0.381: PC54.2 PR72.2 v1(48.63,18.34)
  BOTTOM w0.381: PD7.1 48.81,18.16 v1(48.63,18.34)
N25421528:
  vias: v1(38.42,23.02)
N25421533: length 17.8
  TOP w0.127: v1(49.62,26.99) PR58.1
  TOP w0.762: PR58.1 48.03,26.32 v1(47.4,25.69)
  BOTTOM w0.762: v1(47.4,25.69) 46.82,25.11 43.35,25.11 41.08,22.84 39.22,22.84 37.64,21.26 37.64,18.2 v2(37.65,18.19)
N25421535: length 1.5
  TOP w0.254: PR70.2 40.14,19.97 PU2.8
N25421536: length 1.6
  TOP w0.254: PR76.2 40.4,19.47 PU2.9
N25421576: length 1.9
  TOP w0.165: PU2.13 43.2,17.47 v1(43.42,17.25)
  BOTTOM w0.165: PR202.2 v1(43.42,17.25)
N25421577: length 2.2
  TOP w0.165: v1(42.7,17.41) PU2.12
  BOTTOM w0.165: v1(42.7,17.41) 42.7,17.23 PR203.2
N25421591: length 3.1
  TOP w0.127: PQ7.3 67.57,29.82 v1(67.09,29.34)
  TOP w0.508: PR51.2 68.93,29.38 PQ7.3
N25421602: length 8.7
  TOP w0.254: PQ10.3 33.47,20.1 36.67,16.89 v1(38.49,16.89)
  BOTTOM w0.254: PR201.1 v1(38.49,16.89)
N25421607: length 6.8
  TOP w0.254: PQ9.2 PQ9.5 39.72,24.94 40.12,24.53 PR60.1 41.44,23.63 41.44,22.64 v1(41.52,22.56) 41.92,22.56 42.2,22.28 PU2.5
N25421616: length 3.5
  TOP w0.127: v1(40.49,28.17) PR56.1
  TOP w0.254: PQ9.6 39.23,26.62 PR57.2 39.8,27.19 PR56.1
N25421661: length 2.8
  TOP w0.14: v1(73.38,20.83) 73.77,20.44 PR73.1
  BOTTOM w0.127: PJ5.5 73.59,21.03 73.56,21
  BOTTOM w0.14: v1(73.38,20.83) 73.56,21
N26224666: length 5
  BOTTOM w0.14: Q28.2 81.16,104.9 81.42,104.63 81.71,104.63 81.81,104.73 Q28.3 81.81,106.2 81.94,106.33 v1(82.56,106.33) 82.56,106.66 82.15,107.07 R298.1
N26800092: length 2
  TOP w0.14: TP26.1 148.45,21.07 148.45,21.04 147.88,20.46 U16.71
N26800651: length 6
  TOP w0.254: R22.1 92.97,99.28 94.28,99.28 94.75,98.81 Q4.3 95.51,98.19 95.72,97.97 v1(95.72,97.82) 95.72,97.73 95.52,97.54 Q4.2
N26801737: length 4.6
  TOP w0.14: TP18.1 146.56,31.21 147.01,30.77 147.97,30.77 148.09,30.65 148.09,29.85 147.9,29.66 U16.94
N26804054: length 2.5
  BOTTOM w0.279: CN5.10 38.93,87.99 38.35,87.41 TP35.1
N26804339: length 2.3
  BOTTOM w0.127: TP34.1 27.9,88.13 27.43,88.6 CN5.56
N26804367: length 1.9
  BOTTOM w0.127: TP33.1 26.58,88.43 26.93,88.78 CN5.58
N26947276: length 1.8
  BOTTOM w0.127: R467.1 131.92,25.67 132.17,25.67
  BOTTOM w0.14: C420.2 v1(132.47,25.67) 132.17,25.67
N27049263: length 5.4
  TOP w0.127: v1(162.06,29.96) 162.06,30.49 162.27,30.69 162.95,30.69 163.17,30.47 Q19.3
  TOP w0.254: Q19.3 163.17,29.37 163.28,29.25 163.71,29.25 163.82,29.35 Q19.2 R231.2
N27146970: length 3.7
  TOP w0.127: R418.2 167.22,36.4 v1(167.25,36.38) 167.57,36.06 167.57,34.95 167.89,34.63 U29.5
N27714931: length 4.5
  BOTTOM w0.61: U20.1 v2(36.7,101.41) ; U20.10 v2(27.7,101.41) ; U20.4 v2(33.7,101.41) ; U20.7 v2(30.7,101.41)
  vias: v1(31.86,100.72)
N27777984:
  vias: v1(233.26,15.58)
N27809336: length 2.2
  TOP w0.14: R117.1 30.33,69.22 30.33,68.56 29.95,68.18 U6.4
N27870072: length 9.1
  IN1 w0.762: v2(99.94,128.58) 99.73,128.58 98.91,129.41 98.91,135.31 97.78,136.43 v2(97.78,136.7)
  vias: v1(100.24,129.27)
N27870812: length 1.8
  BOTTOM w0.229: PR90.1 98.23,135.34 v1(97.93,135.64) PU4.7
N27871233: length 8.1
  IN1 w0.762: v2(82.23,130.11) 81.4,130.94 81.4,136.39 v2(80.38,137.42)
  vias: v1(80.35,138.1)
N27872424: length 1.4
  BOTTOM w0.229: PR89.1 81.28,135.85 PU3.7
N27955093: length 21.3
  TOP w0.254: PR31.1 PR32.2 109.2,121.9 109.44,121.65 110.68,121.65 111.55,122.52 111.55,125.44 109,127.99 106.61,127.99 106.08,127.46 103.33,127.46 v1(103.19,127.61)
  BOTTOM w0.254: v1(103.19,127.61) 103.06,127.47 99.44,127.47 99.16,127.2 PR113.2
N27955466: length 7.7
  TOP w0.254: v1(105.64,123.87) 105.84,123.87 106.29,124.33 PR22.1
  BOTTOM w0.254: PR116.1 v1(101.79,125.43) 102.18,125.82 103.68,125.82 v1(105.64,123.87)
N27955489: length 1.3
  BOTTOM w0.254: PC91.1 PR115.1
N27962012: length 4.1
  BOTTOM w0.508: Q34.2 192.57,24.74 191.35,24.74 v1(191.3,24.8) 191.25,24.8 191.06,24.98 R469.1 190.22,25.59 R468.2
N28117117: length 2.2
  BOTTOM w0.14: U32.10 111.88,32.34 R456.1
N28117387: length 2.3
  BOTTOM w0.14: U32.8 112.85,31.54 112.29,32.1 111.59,32.1 R458.1
N28123043: length 2.3
  BOTTOM w0.14: R449.1 116.53,35.49 v1(116.24,35.21) 116.24,35.03 115.85,34.63 U32.17
N28127372: length 4.5
  BOTTOM w0.14: U32.35 120.04,29.14 120.59,28.59 120.59,27.61 121.37,26.82 v1(121.37,26.6) 121.46,26.51 R471.2
N28131147: length 2.1
  BOTTOM w0.14: U32.41 117.04,27 116.16,26.11 TP41.1
N28131150: length 3.5
  BOTTOM w0.14: TP42.1 116.14,25.46 116.6,25.92 116.6,26.16 117.45,27.01 U32.40
N28131472: length 5.4
  BOTTOM w0.14: U32.38 118.25,27.32 119.05,26.52 119.05,24.42 C426.1 R472.2
N28146944: length 2.5
  BOTTOM w0.14: R470.2 119.54,26.55 v1(119.49,26.6) 119.36,26.6 118.64,27.32 U32.37
N28189975: length 4.1
  TOP w0.127: U4.5 33.01,96.09 33.26,96.35 v1(34.66,96.35) 35.04,96.35 35.43,96.74 R93.2
N28192386: length 2.3
  BOTTOM w0.305: CN3.37 61.21,128.45 62.04,129.28 R274.2
  vias: v1(62.04,130.31)
N28293994: length 2.5
  TOP w0.254: v1(214.13,34.07) 213.93,33.87 Q16.2
  TOP w0.508: R222.2 215.04,33.06 Q16.2
N28332391: length 2.8
  TOP w0.14: U16.16 130.68,24.46 130.32,24.1 TP24.1
N28332543: length 5
  TOP w0.127: U16.35 133.88,15.53 133.74,15.4 132.6,15.4 132.28,15.71 130.28,15.71 TP43.1
N28332839: length 2.9
  TOP w0.14: TP27.1 148.48,20.67 148.08,20.26 147.88,20.06 U16.70
N28333200: length 3
  TOP w0.14: U16.87 147.88,26.86 148.09,26.65 148.09,26.55 148.42,26.22 148.8,26.22 149.14,26.56 TP22.1
N28333244: length 4.3
  TOP w0.14: TP21.1 150.41,27.43 148.92,25.94 148.3,25.94 148.18,26.06 U16.85
N28653201: length 10
  TOP w0.14: v1(7.23,90.24) 7.81,90.82 TP3.1
  IN3 w0.14: CN1.B8 4.78,86.6 4.48,86.9 4.48,90.17 4.85,90.55 6.93,90.55 v1(7.23,90.24)
N28712721: length 8.5
  TOP w0.127: v1(9.02,89.86) 9.6,89.86 10.43,90.69 TP4.1
  TOP w0.14: CN1.A8 8.03,85.05 v1(8.19,85.21)
  IN3 w0.127: v1(8.19,85.21) 8.19,87.84 9.02,88.67 v1(9.02,89.86)
N28748831: length 1.1
  TOP w0.127: R72.1 75.43,86.02 75.73,85.71 C70.2
N28749147: length 0.9
  TOP w0.127: R83.1 C79.2
N28749381: length 2.1
  TOP w0.127: C50.2 76.06,88.8 76.26,89.01 v1(76.26,89.36) 75.16,89.36 R61.1
N28749503: length 0.9
  TOP w0.102: C97.2 R101.1
N28749588: length 1
  TOP w0.102: R102.1 87.63,75.3 C102.2
N28852170: length 2.5
  BOTTOM w0.127: R390.2 63.1,84.8 v1(62.9,84.6) U22.5
N28853874: length 5.5
  TOP w0.14: U13.41 28.78,39.11 30.34,40.67 30.34,41.64 30.64,41.94 TP11.1
N29269526: length 12.3
  TOP w0.127: PQ24.2 66.51,136.89 66.78,136.62 67.94,136.62 PR208.2 PR212.1 v1(69.46,137.53)
  IN1 w0.102: v1(75.68,135.59) 74.06,135.59 72.12,137.53 v1(69.46,137.53)
N29269540: length 3.1
  TOP w0.254: PR210.2 60.69,134.84 PQ25.3
N29269542: length 7.4
  TOP w0.127: PR209.2 PR211.1 65.26,138 65.14,138.13 PQ24.3 63.23,138.13 62.72,137.62 PQ25.2
N29271135: length 9.1
  IN1 w1.016: 58.53,123.14 58.53,117.05 v1(56.37,114.89)
  vias: v1(55.66,114.08) v1(59.86,123.32)
N29271139:
  vias: v1(60.36,115.42)
N29271214: length 2
  TOP w0.127: PQ23.3 60.69,120.73 v1(60.69,121.19) PR206.2
N29271227: length 3.3
  TOP w0.127: PR207.2 v1(61.84,118.07) 62.73,118.07 63.23,118.57 PQ23.2
N29632396:
  vias: v1(109.99,110.62)
N29634628:
  vias: v1(106.44,110.62)
N29639135: length 4.4
  TOP w0.127: R489.1 166.09,30.46 166.28,30.64 v1(166.28,30.87) 165.98,31.17 165.98,31.58 166.09,31.69 Q35.3 167.19,31.69 167.36,31.86 167.36,32.23 167.25,32.34 Q35.2
N29643478:
  vias: v1(30.34,98.76)
N30017457: length 1
  TOP w0.102: C449.2 R493.1
N30954436:
  vias: v1(147.31,46.66)
N30954444: length 4.3
  BOTTOM w0.127: v1(145.45,45.27) 145.65,45.46 PR183.2
  BOTTOM w0.254: PR183.2 144.5,46.11 PR185.1 143.88,46.09 143.66,46.31 142.33,46.31
N31161143: length 5.4
  BOTTOM w0.178: PU13.4 145.02,58.69 145.4,59.07 PC174.1
  BOTTOM w0.203: PC174.1 145.64,59.51 145.9,59.77 145.9,61.38 145.72,61.56 PR173.1
N31161147: length 2.2
  BOTTOM w0.178: PC183.1 144.84,53.35 v1(144.54,53.65) 144.54,54.38 144.62,54.46 PU13.12
N31161149: length 2.3
  BOTTOM w0.178: PC184.1 145.8,53.64 v1(145.81,53.65) 145.5,53.95 145.5,54.31 145.42,54.4 PU13.10
N31161190: length 5.7
  BOTTOM w0.178: PU13.5 145.42,58.29 v1(145.68,58.55) 146.42,59.29 PC175.1
  BOTTOM w0.203: PC175.1 146.75,59.51 146.94,59.69 146.94,61.34 146.72,61.56 PR174.2
N31161198: length 5.2
  BOTTOM w0.178: PU13.3 144.62,57.99 v1(144.46,58.15) 144.46,59.35 144.39,59.43 PC176.1
  BOTTOM w0.203: PR172.1 144.76,61.56 144.88,61.43 144.88,59.98 PC176.1
N31161958: length 5.3
  BOTTOM w0.178: PR137.1 122.93,114.75 122.71,114.96 121.41,114.96 PC120.1 120.35,114.43 120.3,114.38 PU7.4
N31161974: length 2.3
  BOTTOM w0.178: PC119.1 v1(114.72,115.02) 114.77,115.02 114.95,114.84 115.65,114.84 115.7,114.78 PU7.12
N31161976: length 2.4
  BOTTOM w0.178: PU7.10 115.7,113.98 115.6,113.87 114.9,113.87 114.77,113.75 v1(114.72,113.75) 114.59,113.87 PC124.1
N31162017: length 5.5
  BOTTOM w0.178: PU7.5 119.49,113.98 v1(119.98,113.49) 120.75,113.49 PC125.1 121.38,113.87 122.75,113.87 122.93,113.69 PR138.2
N31162025: length 5.3
  BOTTOM w0.178: PU7.3 119.85,114.78 v1(119.95,114.88) 120.27,114.88 PC117.1 121.36,115.98 122.5,115.98 PR136.1
N32459172: length 3
  TOP w0.203: PR48.2 104.21,30.46 v1(104.21,30.11)
  BOTTOM w0.203: PC195.1 104.21,30.44 v1(104.21,30.11) 104.21,30.06 103.92,29.76 PU15.4
N32459334: length 2.5
  TOP w0.203: v1(103.56,30.11) 102.75,30.93 PR47.1
  BOTTOM w0.203: PU15.3 103.52,29.99 103.56,30.04 v1(103.56,30.11)
N32459384: length 2.7
  TOP w0.127: v1(89.42,26.85) PC40.1
  TOP w0.508: PR52.2 90.29,27.92 90.18,28.03 PC40.1
N32810872: length 1.8
  BOTTOM w0.127: PC84.1 v1(132.78,131.27)
  BOTTOM w0.254: PR99.1 PC84.1
N32810957: length 3.6
  BOTTOM w0.127: v1(130.42,134.54) PR93.2
  BOTTOM w0.229: PU5.11 130.04,133.19 130.29,133.43 PR98.1
  BOTTOM w0.254: PR98.1 131.17,133.9 131.25,133.99 PR93.2
N32810977: length 2.7
  TOP w0.127: PC13.1 v1(130.2,126.76)
  TOP w0.381: PR17.2 PC13.1
N32811094: length 1.9
  TOP w0.254: PC34.1 v1(146.55,81.49)
  BOTTOM w0.127: v1(146.55,81.49) v1(147.2,81.49)
  BOTTOM w0.254: PC34.1 v1(146.55,81.49)
N32811135: length 1.7
  BOTTOM w0.229: PC163.2 142.8,79.48 PU11.17
N32811186: length 3.7
  BOTTOM w0.127: v1(146.04,84.93) PR158.2
  BOTTOM w0.203: PU11.11 143.73,82.87 PR162.1 144.76,84.13 145.12,84.49 PR158.2
N32811216: length 2.7
  TOP w0.127: PC33.1 v1(138.41,83.54)
  TOP w0.381: PR40.2 PC33.1
N33973281: length 2.4
  BOTTOM w0.127: v1(112.88,88.02) PR153.1
  BOTTOM w0.381: PU9.1 113.73,89.52 113.23,89.02 PR153.1
N33973285: length 4.5
  BOTTOM w0.254: PR159.2 PC160.1 116.64,84.61 v1(115.14,86.1) 114.73,86.52 PU9.5
N33973296: length 6
  BOTTOM w0.381: PU9.3 116.01,88.11 118.68,85.44 v1(118.71,85.44) PR156.1
N35788542: length 3.5
  BOTTOM w0.381: PR179.1 PC185.1 137.53,49.29 137.09,48.85 136.03,48.85
N35790435: length 4.4
  BOTTOM w0.381: 136.03,46.31 PC189.1 PR182.2
N36056010: length 16.2
  BOTTOM w0.508: v1(43.39,76.01) 43.39,78.23 44.25,79.09 49.31,79.09 49.82,79.61 49.82,81.02 50.56,81.75 50.56,83.05 49.11,84.49 PR161.1
  vias: v1(44.04,76.06) v1(44.68,76.03) v1(44.84,77.45) v1(44.94,74.78)
N36056030: length 3.9
  BOTTOM w0.508: PR166.2 PR167.1 48.89,81.16 48.89,81.16 v1(48.66,80.93) 47.36,80.93 47.09,80.66 PU12.6
N36056032: length 3.2
  TOP w0.508: PR41.2 46.1,81.07 45.7,81.47 v1(45.7,81.55)
  BOTTOM w0.508: PU12.4 45.19,81.04 v1(45.7,81.55) PC161.1
N36056052: length 1.1
  BOTTOM w0.508: PR166.1 PR161.2
N36056070: length 7.7
  BOTTOM w0.127: v1(50.28,76.36) PC167.1
  BOTTOM w0.508: PC167.1 PR170.1 48.89,75.65 48.89,78.14 48.64,78.39 47.34,78.39 47.09,78.14 PU12.1
N36056085: length 1.8
  BOTTOM w0.508: PU12.5 46.14,80.82 46.97,81.65 PR165.1
N36057265: length 11.6
  BOTTOM w0.254: PC153.1 127.4,90.4 130.58,93.58 131.46,93.58 133.46,91.58 PR151.1
  vias: v1(126.2,88.19)
N36057275: length 3.9
  BOTTOM w0.203: PR155.1 PR154.2 133.4,88.46 v1(132.52,89.34) 132.13,88.94 PU10.6
N36057285:
  vias: v1(128.89,90.91)
N36057305: length 2.1
  BOTTOM w0.127: PR151.2 v1(134.48,90.37)
  BOTTOM w0.203: PR154.1 PR151.2
N36057323: length 4.3
  BOTTOM w0.254: PR163.1 132.91,83.53 133.46,84.09 PC158.1 133.09,84.65 132.61,84.17 132.28,84.17 132.13,84.32 PU10.1
N36057338: length 2
  BOTTOM w0.203: PR152.1 131.18,89.35 PU10.5

## Copper pours and planes (outline as drawn)
1.8V_LDO on BOTTOM (solid shape): 149.48,37.4 149.96,37.4 149.97,37.38 149.97,37.35 149.97,36.79 149.97,35.95 149.9,35.87 148.37,35.87 148.17,36.07 148.17,38 148.32,38.16 148.73,38.16
1.35VSUS_VIN on BOTTOM (solid shape): 96.51,36.23 96.51,34.52 97.4,33.63 97.4,30.29 97.71,29.98 97.71,26.37 97.46,26.12 95.34,26.12 95.08,26.38 95.08,29.65 94.63,30.1 93.56,30.1 93.33,30.33 93.33,35.26 94.42,36.35 96.38,36.35
3VPCU_VIN on BOTTOM (solid shape): 126.31,139.13 126.31,135.76 126.78,135.29 126.78,134.7 126.63,134.55 126.63,134.14 126.66,134.14 126.78,134.02 126.78,133.58 127.19,133.18 127.19,133.11 127.17,133.08 127.14,133.06 126.55,133.06 126.55,132.86 127.14,132.86 127.17,132.85 127.19,132.81 127.19,132.66 127.17,132.63 127.14,132.61 126.55,132.61 126.55,132.41 127.14,132.41 127.17,132.4 127.19,132.36 127.19,132.21 127.17,132.18 127.14,132.16 126.55,132.16 126.55,131.96 127.14,131.96 127.17,131.95 127.19,131.91 127.19,131.83 127.07,131.71 126.55,131.71 126.55,131.7 125.97,131.7 124.99,130.72 124.99,130.33 124.56,129.9 123.49,129.9 123.37,130.02 123.37,135.43 124.22,136.28 124.22,139.18 124.36,139.32 126.12,139.32
5VPCU_VIN on BOTTOM (solid shape): 140.93,89.06 140.93,84.46 140.92,84.42 140.88,84.41 140.6,84.41 140.32,84.13 140.32,83.75 141.31,82.76 141.31,82.7 141.3,82.66 141.26,82.64 140.65,82.64 140.65,82.45 141.26,82.45 141.3,82.43 141.31,82.4 141.31,82.24 141.3,82.21 141.26,82.19 140.65,82.19 140.65,82 141.26,82 141.3,81.98 141.31,81.94 141.31,81.79 141.3,81.76 141.26,81.74 140.65,81.74 140.65,81.55 141.26,81.55 141.3,81.53 141.31,81.49 141.31,81.31 141.29,81.29 140.65,81.29 140.65,81.29 138.26,81.29 138.11,81.44 138.11,85.7 137.88,85.93 137.88,88.83 138.49,89.44 140.55,89.44
+1.2V_ASM on BOTTOM (solid shape): 120.39,28.5 120.39,27.48 120.95,26.92 120.95,25.61 120.85,25.51 120.21,25.51 120.05,25.67 120.05,26.63 119.65,27.03 119.27,27.03 119.02,27.29 119.02,28.81 119.05,28.84 120.05,28.84
+1.2V_ASM on BOTTOM (solid shape): 115.14,28.34 115.14,27.31 115.8,26.64 115.8,26.5 115.79,26.48 115.63,26.1 115.8,25.73 115.8,25.23 115.64,24.97 115.66,24.67 115.65,24.57 115.57,24.53 114.33,24.53 113.29,23.49 110.39,23.49 110.11,23.77 110.11,25.65 110.32,25.86 113.78,25.86 114.09,25.55 114.65,25.55 114.93,25.82 114.93,25.98 115.07,26.13 115.07,26.83 114.95,26.95 114.95,28.33 114.98,28.36 115.11,28.36
+1.2V_ASM on IN2 (solid shape): outline of 337 points within 111.71,24.24 121.67,35.45
+1.05V on BOTTOM (solid shape): outline of 171 points within 104.72,86.86 122.96,105.59
+1.8V_EMMC on TOP (solid shape): 60.11,101.35 60.11,100.29 60.07,100.21 59.98,100.2 59.84,100.21 59.72,100.13 59.67,99.97 59.75,99.81 59.78,99.74 59.75,99.66 59.7,99.61 59.68,99.56 59.67,99.42 59.74,99.31 59.78,99.24 59.74,99.16 59.67,99.01 59.71,98.85 59.72,98.82 59.72,98.8 59.71,98.77 59.62,98.69 59.19,98.69 59.1,98.77 59.1,99.39 59.11,99.4 59.12,99.49 59.11,99.57 59.1,99.58 59.1,99.89 59.11,99.9 59.1,100.08 58.97,100.2 58.96,100.21 58.69,100.48 58.69,100.58 58.73,100.62 59.01,100.62 59.16,100.47 59.17,100.45 59.21,100.35 59.3,100.28 59.56,100.32 59.6,100.58 59.6,100.59 59.6,100.66 59.16,101.1 59.16,101.39 59.28,101.51 59.96,101.51
+1.8V_EMMC on BOTTOM (solid shape): 60.9,103.26 60.9,102.49 60.56,102.15 60.56,98.57 60.23,98.25 59.81,98.25 59.77,98.29 59.76,98.31 59.53,98.59 59.17,98.55 59.07,98.55 59.01,98.64 59.01,98.71 59.02,98.73 59.11,98.98 59.01,99.23 59.01,100.93 59.02,100.95 59.03,100.97 59.13,101.23 59.03,101.49 59.02,101.51 59.01,101.53 59.01,101.82 59.8,102.61 60.08,102.61 60.08,103.33 60.11,103.36 60.79,103.36
+1.8V_S5 on TOP (solid shape): 34.91,98.38 34.91,97.11 34.66,96.86 33.52,96.86 33.52,98.13 33.77,98.13 34.27,98.63 34.66,98.63
+1.8V_S5 on TOP (solid shape): 68.64,81.47 69.33,81.47 69.5,81.3 69.5,79.7 69.36,79.56 69.21,79.56 69.07,79.7 66.58,79.7 66.32,79.96 66.32,81.9 66.33,81.92 66.34,81.94 66.54,82.14 67.97,82.14
+1.8V_S5 on TOP (solid shape): outline of 250 points within 37.93,77.17 54.4,90.67
+1.8V_S5 on BOTTOM (solid shape): 58.77,84.09 60.04,84.09 60.05,84.08 60.05,84.06 60.05,83.8 59.98,83.72 59.96,83.72 59.65,83.54 59.63,83.18 59.63,83.08 59.54,83.04 58.55,83.04 58.3,83.28 58.3,83.88 58.53,84.11 58.77,84.11
+1.8V_S5 on BOTTOM (solid shape): outline of 126 points within 82.48,101.94 102.88,106.98
+1.8V_S5 on IN1 (solid shape): outline of 431 points within 71.56,100.21 86.18,105.13
+1.8V_S5 on IN1 (solid shape): outline of 2716 points within 66.45,80.28 110.27,87.77
+1.8V_S5 on IN2 (solid shape): outline of 2325 points within 52.7,74.66 73.54,103.78
+1.24V_S5 on BOTTOM (solid shape): 125.6,85.95 125.6,84.93 125.31,84.64 125.31,80.62 124.88,80.19 116.16,80.19 113.94,82.41 113.94,84.99 114.06,85.12 114.79,85.12 115.18,84.72 115.19,84.7 115.2,84.61 115.2,84.12 115.61,84.12 116.37,83.36 122.12,83.36 122.34,83.57 122.58,83.57 122.91,83.9 122.93,83.91 122.95,83.91 123.3,84.15 123.22,84.56 123.22,85.9 123.38,86.05 125.5,86.05
+1.35VSUS on TOP (solid shape): outline of 280 points within 84.24,27.89 101.25,33.95
+1.35VSUS on TOP (solid shape): outline of 866 points within 49.15,37.83 72.69,51.62
+1.35VSUS on TOP (solid shape): outline of 9316 points within 46.11,38.59 119.73,83.38
+1.35VSUS on BOTTOM (solid shape): 100.78,29.08 100.78,28.49 101.16,28.12 102.39,28.12 102.43,28.1 102.44,28.07 102.44,27.97 102.39,27.91 101.42,27.91 101.42,27.91 99.54,27.91 99.36,28.09 99.36,29.15 99.5,29.3 100.57,29.3
+1.35VSUS on BOTTOM (solid shape): 85.74,83.37 85.87,83.34 86,83.37 86.01,83.37 86.31,83.37 86.53,83.16 86.72,83.16 86.81,83.07 86.84,83.01 86.9,82.96 86.92,82.92 86.92,82.63 86.91,82.62 86.86,82.61 86.82,82.6 86.77,82.57 86.72,82.51 86.68,82.49 86.22,82.49 86.05,82.66 85.9,82.66 85.87,82.67 85.85,82.7 85.52,82.96 85.17,82.73 85.15,82.7 85.13,82.7 84.91,82.7 84.73,82.52 84.73,82.06 84.53,81.86 84.4,81.86 84.3,81.96 84.3,82.14 84.42,82.25 84.42,82.76 84.23,82.95 83.91,82.95 83.74,83.13 83.74,83.29 83.82,83.37 85.73,83.37
+1.35VSUS on BOTTOM (solid shape): 96.48,83.35 96.52,83.35 96.56,83.33 96.61,83.31 96.65,83.24 96.88,83.02 96.88,82.89 96.93,82.84 96.95,82.81 96.98,82.72 97.06,82.64 97.36,82.64 97.46,82.53 97.46,82.41 97.46,82.4 97.42,82.32 97.41,82.23 97.42,82.12 97.46,82.01 97.46,81.71 97.26,81.5 97.13,81.5 97.05,81.58 97.05,81.87 97.06,81.88 97.08,82.16 96.9,82.37 96.89,82.37 96.81,82.45 96.57,82.45 96.54,82.46 96.52,82.48 96.35,82.62 96.13,82.56 96.06,82.5 96.04,82.4 96.05,82.3 95.94,82.19 95.66,82.19 95.61,82.24 95.61,82.52 95.5,82.62 95.36,82.62 95.33,82.62 95.29,82.63 95.27,82.67 95.25,82.76 95.21,82.85 95.2,82.86 95.2,82.92 95.1,83.03 94.74,83.03 94.56,82.84 94.06,82.84 93.93,82.98 93.93,83.22 93.94,83.23 94,83.28 94.05,83.34 94.21,83.5 96.33,83.5
+1.35VSUS on BOTTOM (solid shape): outline of 5175 points within 46.19,31.8 121.86,71.41
+1.35VSUS on IN1 (solid shape): outline of 265 points within 93.94,47.11 98.31,57.52
+1.35VSUS on IN1 (solid shape): outline of 340 points within 59.38,47.33 63.76,57.34
+1.35VSUS on IN1 (solid shape): outline of 450 points within 105.83,46.99 109.4,59.18
+1.35VSUS on IN1 (solid shape): outline of 484 points within 70.75,47.33 74.29,59.26
+1.35VSUS on IN1 (solid shape): outline of 605 points within 78.05,40.74 91.71,51.53
+1.35VSUS on IN1 (solid shape): outline of 610 points within 45.98,46.3 54.77,60.46
+1.35VSUS on IN2 (solid shape): outline of 1717 points within 71.06,50.71 80.74,59.81
+1.35VSUS on IN2 (solid shape): outline of 1794 points within 106.24,50.53 115.49,59.81
+1.35VSUS on IN2 (solid shape): outline of 1772 points within 53.15,51.11 62.4,59.81
+1.35VSUS on IN2 (solid shape): outline of 1803 points within 88.33,50.53 97.58,59.81
+1.35VSUS_SRC on BOTTOM (solid shape): 84.53,31.4 88.46,31.4 88.48,31.4 88.5,31.38 89.6,30.29 89.6,29.89 89.84,29.65 89.89,29.6 89.96,29.57 89.97,29.56 89.99,29.54 89.99,20.78 89.67,20.46 86.62,20.46 84.54,22.53 84.54,23.53 83.4,24.68 81.21,24.68 80.79,25.1 80.79,31.51 81.18,31.89 84.03,31.89 84.03,31.89
+3V on TOP (solid shape): 199.41,21.23 199.41,20.82 199.28,20.68 199.14,20.68 198.88,20.43 198.88,20.03 197.87,19.02 196.95,19.02 196.77,19.2 196.77,20.22 197.87,21.32 199.33,21.32
+3V on TOP (solid shape): 231.13,24.87 231.13,23.45 230.97,23.3 229.86,23.3 229.48,23.68 229.48,23.75 229.5,23.78 229.5,23.79 229.56,24.01 229.5,24.23 229.5,24.32 229.48,24.35 229.48,24.54 229.86,24.92 231.08,24.92
+3V on TOP (solid shape): outline of 154 points within 26.82,57.89 41.39,73.56
+3V on TOP (solid shape): outline of 1609 points within 110.15,31.15 180.1,111.68
+3V on BOTTOM (solid shape): 89.96,108.71 89.96,106.62 89.75,106.41 83.14,106.41 82.05,107.51 81.6,107.51 81.49,107.4 81.47,107.38 81.45,107.36 81.33,107.24 81.33,106.9 81.14,106.71 80.87,106.71 80.85,106.72 80.83,106.73 80.61,106.89 80.34,106.87 80.31,106.86 80.28,106.88 80.15,107.01 80.15,108.47 80.45,108.77 83.04,108.77 83.18,108.91 83.2,108.92 83.22,108.93 88.09,108.93 88.11,108.95 89.72,108.95
+3V on BOTTOM (solid shape): 116.54,113.62 116.54,113.53 116.53,113.5 116.49,113.48 115.73,113.48 115.73,113.28 116.49,113.28 116.53,113.26 116.54,113.23 116.54,113.07 116.26,112.78 116.26,110.29 116.09,110.12 114.32,110.12 114.14,109.94 113.87,109.94 113.29,109.36 113.26,109.36 112.97,109.36 112,110.33 112,113.06 112.15,113.21 113.02,113.21 113.41,112.82 113.66,112.82 113.67,112.81 113.69,112.84 113.71,112.85 113.9,112.9 114.03,113.04 114.03,113.05 114.45,113.47 114.49,113.44 114.83,113.38 115.08,113.62 115.09,113.66 115.69,113.66 115.7,113.67 116.49,113.67
+3V on BOTTOM (solid shape): outline of 165 points within 35.75,71.06 68.08,109.24
+3V on IN1 (solid shape): outline of 200 points within 176.92,16.8 198.39,33.71
+3V on IN2 (solid shape): outline of 955 points within 88.98,100.2 114.39,111.91
+3V on IN3 (solid shape): outline of 1337 points within 196.79,12.94 232.9,25.07
+3V on IN3 (solid shape): outline of 2644 points within 47.12,101.13 82.07,127.15
+3V_ASM on TOP (solid shape): outline of 411 points within 111.42,25.61 121.85,35.71
+3V_ASM on BOTTOM (solid shape): 113.89,28.8 113.89,28.47 113.32,27.9 111.22,27.9 111.04,28.07 111.04,28.77 111.11,28.84 113.85,28.84
+3V_ASM on BOTTOM (solid shape): 121.31,29.65 121.31,29.08 121.32,29.08 121.32,28.78 121.26,28.72 120.76,28.72 120.23,29.26 120.23,29.26 120.04,29.44 119.07,29.44 119.05,29.46 119.05,29.62 119.07,29.64 120.12,29.64 120.37,29.89 120.5,29.89 120.51,29.89 121.07,29.89
+3V_ASM on BOTTOM (solid shape): 118.13,26.84 118.13,26.51 118.12,26.41 118.13,26.31 118.13,24.73 117.83,24.43 116.88,24.43 116.58,24.73 116.58,25.62 116.8,25.84 116.8,26.08 117.66,26.95 118.03,26.95
+3V_ASM on BOTTOM (solid shape): 112.24,38.91 112.24,34.37 112.46,34.16 112.46,33.89 112.74,33.61 113.55,33.61 113.83,33.33 113.83,33.08 113.8,33.05 112.7,33.05 112.53,33.22 112.49,33.27 111.88,33.87 111.03,33.87 111,33.9 111,34.28 110.88,34.41 110.31,34.41 109.81,33.9 107.8,33.9 107.76,33.95 107.76,34.4 107.81,34.46 109.31,34.46 109.74,34.89 109.74,37.03 109.51,37.26 107.55,37.26 105.58,35.29 105.04,35.29 104.93,35.17 102.32,35.17 102.3,35.2 102.3,35.67 102.33,35.71 104.05,35.71 104.13,35.79 104.13,36.37 104.04,36.46 102.31,36.46 102.29,36.48 102.29,36.95 102.34,37 104.05,37 104.4,37.35 106.39,37.35 107.2,38.15 107.73,38.15 107.96,38.39 107.96,39.46 108.24,39.74 111.4,39.74
+3V_ASM on IN2 (solid shape): outline of 98 points within 120.69,29.38 123.64,34.34
+3V_CR on TOP (solid shape): 25.58,33.38 25.58,33.1 24.73,32.25 24.73,31.84 23.75,30.87 22.99,30.87 22.84,31.02 22.84,31.8 22.96,31.92 23.66,31.92 24.1,32.36 24.1,32.87 24.64,33.41 25.55,33.41
+3V_EC on TOP (solid shape): 129.49,26.99 130.32,26.99 130.44,26.87 130.44,26.56 130.44,26.56 130.44,26.06 130.07,25.7 127.03,25.7 127.02,25.69 127,25.69 126.82,25.51 126.82,24.78 126.69,24.66 124.62,24.66 124.34,24.93 124.34,26.06 125.36,27.07 129.41,27.07
+3V_EMMC on TOP (solid shape): outline of 337 points within 55.55,95.9 59.1,99.13
+3V_EMMC on BOTTOM (solid shape): 56.68,100.09 56.68,98.96 56.45,98.74 56.45,98.01 56.5,97.96 56.6,97.84 56.84,97.59 56.84,97.58 57.17,97.29 57.55,97.49 57.62,97.53 57.71,97.5 58.09,97.13 58.31,97.13 58.35,97.11 58.36,97.08 58.36,96.09 58.13,95.86 58.06,95.82 58,95.78 57.97,95.75 57.93,95.74 57.82,95.74 57.81,95.75 57.7,95.8 57.58,95.82 57.46,95.79 57.36,95.74 54.58,95.74 54.55,95.77 54.55,97.18 55.03,97.67 55.03,100.26 55.12,100.34 56.43,100.34
+3V_M2 on TOP (solid shape): 28.63,97.67 28.63,96.27 27.99,95.62 26.98,95.62 26.1,94.75 25.97,94.75 25.77,94.95 25.77,96.5 27.04,97.77 28.54,97.77
+3V_M2 on TOP (solid shape): 33.8,94.37 32.88,93.45 32.88,92.44 32.65,92.21 32.47,92.21 32.27,92.41 32.27,93.57 33.52,94.82 33.52,96.09 33.8,96.09
+3V_M2 on BOTTOM (solid shape): outline of 635 points within 21.91,81.99 42.71,91.39
+3V_RTC on TOP (solid shape): 84.5,89.06 84.5,88.54 84.39,88.43 83.83,88.43 83.51,88.11 83.51,87.85 83.47,87.81 83.03,87.81 82.94,87.9 82.94,88.44 83.3,88.81 83.3,89.21 83.32,89.25 83.35,89.27 83.49,89.29 83.61,89.37 83.62,89.38 83.66,89.4 84.16,89.4
+3V_S5 on TOP (solid shape): 63.22,84.35 63.22,83.24 62.96,82.98 62.47,82.98 62.35,82.86 62.34,82.85 61.61,82.12 60.13,82.12 59.93,82.33 59.93,82.91 59.98,82.96 60,82.96 60.26,83.09 60.36,83.37 60.36,83.39 60.37,83.41 60.53,83.56 60.65,83.56 61.09,84 61.09,84.31 61.45,84.66 62.9,84.66
+3V_S5 on TOP (solid shape): 37.18,57.76 37.25,57.73 37.28,57.66 37.47,57.32 37.86,57.32 37.9,57.33 37.93,57.32 38.67,56.57 38.67,48.29 40.64,46.32 40.64,34.87 40.35,34.57 40.35,34.55 38.72,32.92 38.51,32.92 38.16,33.27 38.16,35.77 38.01,35.92 38.01,37.58 38.01,37.72 37.53,38.21 37.53,44.1 36.79,44.84 36.79,48.01 37.14,48.35 37.14,49.74 37.14,49.75 37.18,53.23 35.13,56.04 34.32,56.52 33.44,56.85 33.42,56.86 33.39,56.9 33.39,57.56 33.59,57.76
+3V_S5 on TOP (solid shape): 124.17,25.8 124.17,24.56 124.16,24.53 124.13,24.51 120.04,21.04 120.83,15.74 120.84,15.72 120.84,15.68 120.5,15.35 120.49,15.34 120.47,15.33 104.44,15.33 103.37,16.4 103.37,20.66 103.83,21.12 104.8,21.12 105.28,20.64 105.28,19.99 105.27,19.97 105.25,19.95 105.06,19.62 105.25,19.29 105.27,19.28 105.28,19.26 105.28,17.84 105.9,17.22 107.35,17.22 107.64,16.92 107.64,16.4 107.73,16.32 111.17,16.32 111.49,16 113.64,16 113.96,16.13 114.09,16.44 114.09,16.56 114.09,16.58 114.1,16.59 114.53,17.02 115.59,17.02 116.19,16.42 116.19,16.4 116.45,16.11 116.83,16.2 117.82,16.2 118.48,16.86 118.48,20.19 118.25,20.42 118.25,21 118.21,21.03 118.2,21.05 118.2,21.07 118.2,21.87 118.6,22.27 118.79,22.27 118.79,22.27 122.34,25.82 122.36,25.83 122.38,25.84 123.2,25.84 123.53,26.17 123.8,26.17
+3V_S5 on BOTTOM (solid shape): 116.28,118.83 116.28,116.13 116.6,115.82 116.6,115.53 116.58,115.5 116.54,115.48 115.73,115.48 115.73,115.28 116.54,115.28 116.58,115.27 116.6,115.23 116.6,115.16 116.52,115.08 115.73,115.08 115.73,115.07 115.25,115.07 114.83,115.49 113.94,115.49 113.71,115.72 113.71,115.73 113.63,115.81 113.63,118.38 114.23,118.97 116.14,118.97
+3V_S5 on BOTTOM (solid shape): 62.11,84.09 62.14,84.08 62.16,84.04 62.16,82.34 61.89,82.07 60.08,82.07 59.93,82.22 59.93,82.91 59.98,82.96 60,82.96 60.25,83.07 60.36,83.33 60.36,83.35 60.59,83.57 60.59,83.84 60.59,83.86 60.6,83.87 60.75,84.02 60.75,84.05 60.76,84.07 60.78,84.09 60.8,84.09
+3V_S5 on IN1 (solid shape): 41.57,34.5 41.57,32.9 41.52,32.85 38.39,32.85 38.37,32.87 38.37,33.31 38.85,33.79 39.6,34.54 41.52,34.54
+3V_S5 on IN1 (solid shape): 131.4,93.05 131.4,91.64 131.07,91.32 127.57,91.32 127.47,91.42 127.44,91.51 127.5,91.59 128.93,92.69 129.77,94.29 129.78,94.31 129.82,94.32 130.13,94.32
+3V_S5 on IN1 (solid shape): outline of 317 points within 100.23,29.01 113.65,33.61
+3V_S5 on IN1 (solid shape): outline of 711 points within 23.6,82.33 61.17,91.65
+3V_S5 on IN2 (solid shape): outline of 172 points within 59.96,82.05 64.93,92.21
+3V_S5 on IN2 (solid shape): outline of 455 points within 103.64,20.38 108.51,30.48
+3V_S5 on IN3 (solid shape): 131.22,95.83 131.26,95.82 131.27,95.78 131.27,94.12 132.35,93.04 132.35,92.08 131.86,91.59 129.71,91.59 129.17,92.13 129.17,93.01 129.18,93.02 129.77,94.31 129.9,95.72 129.93,95.8 130.01,95.83
+3V_S5 on IN3 (solid shape): outline of 168 points within 31.96,56.06 40.07,87.91
+3VPCU on BOTTOM (solid shape): 133.74,56.14 133.74,50.68 133.57,50.51 131.67,50.51 131.18,51 131.17,51.03 131.17,51.06 131.15,51.46 130.78,51.62 130.7,51.64 130.66,51.72 130.66,56.17 131.31,56.82 133.06,56.82
+3VPCU on BOTTOM (solid shape): 126.46,120.02 126.46,116.31 126.39,116.24 120.74,116.24 119.57,115.07 118.68,115.07 118.68,115.08 117.9,115.08 117.86,115.13 117.86,115.23 117.87,115.26 117.9,115.28 118.68,115.28 118.68,115.48 117.9,115.48 117.87,115.5 117.86,115.53 117.86,115.93 118.12,116.2 118.12,117.7 118.59,118.17 119.61,118.17 121.41,119.97 121.55,119.97 121.62,119.98 121.68,120.02 121.72,120.05 121.74,120.09 121.76,120.11 121.79,120.11 126.36,120.11
+3VPCU on BOTTOM (solid shape): 119.65,113.3 119.71,113.22 119.78,113.16 120.16,112.78 123.38,112.78 123.6,112.57 123.6,110.53 123.01,109.94 122.94,109.91 122.87,109.94 122.82,109.99 122.76,110.03 122.6,110.1 122.43,110.12 121.43,110.12 121,110.12 121,110.12 118.32,110.12 118.12,110.32 118.12,112.85 117.85,113.12 117.85,113.23 117.87,113.26 117.9,113.28 118.68,113.28 118.68,113.48 117.9,113.48 117.87,113.5 117.85,113.53 117.85,113.64 117.89,113.68 118.68,113.68 118.71,113.71 119.24,113.71
+3VPCU on BOTTOM (solid shape): 132.67,100.44 132.67,98.16 132.67,97.45 132.67,97.43 132.66,97.41 132.31,97.06 130.91,97.06 130.56,97.42 129.85,98.12 129.84,98.14 129.8,98.37 129.68,98.54 129.26,98.61 128.98,98.3 128.91,98.22 128.81,98.25 128.24,98.76 127.59,99.17 127.57,99.19 127.56,99.22 127.56,100.38 127.92,100.74 132.38,100.74
+3VPCU on IN1 (solid shape): outline of 1410 points within 120.82,54.24 134.25,120.45
+3VPCU_EC on TOP (solid shape): 136.02,23.83 136.38,23.83 136.38,23.47 135.83,22.91 135.83,20.88 135.09,20.15 132.6,20.15 132.34,20.4 132.6,20.66 134.45,20.66 135.27,21.47 135.27,23.07
+3VPCU_EC on BOTTOM (solid shape): 150.07,30.59 150.07,28.15 149.95,28.02 149.53,28.02 149.42,28.13 149.42,29.04 149.18,29.28 148.78,29.28 148.3,28.8 148.16,28.8 147.97,28.99 147.97,30.59 148.07,30.69 149.97,30.69
+3VPCU_EC on BOTTOM (solid shape): 132.69,20.51 132.69,20.26 132.6,20.17 132.02,20.17 131.15,19.31 131.15,19.01 130.9,18.76 130.64,19.01 130.64,20.01 130.72,20.19 130.9,20.27 131.06,20.27 131.5,20.71 132.5,20.71
+3VPCU_EC on IN3 (solid shape): 132.88,20.51 132.88,20.25 132.78,20.15 132.37,20.15 132.17,19.94 132.17,16.98 132.25,16.39 132.81,16.59 132.81,16.6 132.85,16.64 133.08,16.64 133.25,16.81 139.38,16.81 139.64,17.07 139.64,17.58 139.88,17.83 139.9,17.84 140.12,17.84 140.85,17.1 140.85,15.26 140.63,15.04 131.79,15.04 131.08,15.75 131.08,17.02 131.1,17.05 131.47,17.27 131.41,17.69 131.41,20.55 131.63,20.77 132.62,20.77
+3VPCU_SRC on BOTTOM (solid shape): 131.03,123.44 131.03,121.3 130.58,120.85 130.58,114.59 130.5,114.51 125,114.51 124.94,114.44 124.9,114.43 124.87,114.44 124.73,114.58 124.73,115.52 124.71,115.63 124.69,115.7 124.69,115.71 124.69,115.75 124.78,115.83 126.63,115.83 126.96,116.16 126.96,120.1 126.66,120.4 124.37,120.4 123.43,121.34 123.43,123.6 124.09,124.26 130.21,124.26
+5V on TOP (solid shape): 214.05,31.87 214.07,31.87 214.08,31.85 214.18,31.76 214.18,30.74 213.86,30.41 213.84,30.4 213.82,30.39 212.49,30.39 212.47,30.4 212.45,30.41 212.05,30.81 212.05,31.41 212.51,31.87
+5V on TOP (solid shape): 25.23,76.75 25.8,76.75 25.84,76.78 25.95,76.81 26.01,76.71 26.01,75.82 25.81,75.62 23.35,75.62 23.13,75.84 23.13,76.88 23.36,77.12 24.86,77.12
+5V on TOP (solid shape): 231.4,21.06 233.13,21.06 233.17,21.03 233.17,17.17 232.99,17 232.26,17 232.25,17 231.49,17 231.47,17 231.45,17.01 230.13,18.33 228.79,18.33 228.54,18.59 228.54,20.91 228.77,21.15 228.8,21.15 228.81,21.15 229.17,21.11 229.5,21.23 229.54,21.26 229.58,21.29 231.17,21.29
+5V on TOP (solid shape): 144.55,43.48 144.55,43.45 144.55,43.43 144.57,43.01 144.96,42.87 145.05,42.85 145.09,42.77 145.09,40.26 145.08,40.24 145.06,40.22 145.03,40.22 143.41,40.22 142.19,41.44 142.19,42.6 142.29,42.84 142.21,43.09 142.2,43.12 142.21,43.15 142.29,43.23 142.89,43.23 143.18,43.53 144.5,43.53
+5V on BOTTOM (solid shape): 146.94,29.34 146.94,27.75 146.5,27.31 145.36,27.31 145.29,27.34 145.23,27.35 145.21,27.35 145.18,27.38 145.18,28.71 145.05,28.84 145.05,28.96 144.93,28.96 144.89,29 144.89,29.29 145.05,29.45 146.83,29.45
+5V on BOTTOM (solid shape): 145.92,54.48 146.12,54.48 146.12,55.36 146.31,55.36 146.32,55.33 146.41,55.2 146.53,55.11 146.67,55.07 146.82,55.08 146.94,55.05 147.07,55.06 147.09,55.07 147.13,55.04 148.03,55.04 148.2,55.21 149.49,55.21 149.66,55.04 149.66,53.65 149.36,53.35 149.36,50.83 148.83,50.3 146.72,50.3 146.71,50.31 146.42,50.31 146.41,50.32 146.06,50.32 145.96,50.42 145.96,50.98 146.25,51.27 146.25,53.82 145.99,54.08 145.82,54.08 145.74,54.16 145.74,55.28 145.82,55.36 145.92,55.36
