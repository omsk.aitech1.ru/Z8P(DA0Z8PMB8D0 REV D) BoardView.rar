# Allegro board Quanta Z8P DA0Z8PMB8D0 REV D - BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PGND: length 9.3
  TOP w0.508: R241.1 v1(114.64,26.65)
  IN2 w0.508: v1(110.69,29.45) 110.69,29.1 111.09,28.7 111.74,28.7 111.91,28.86 112.66,28.86 114.64,26.88 v1(114.64,26.65)
  BOTTOM w0.203: v1(114.64,26.65) U32.47
  BOTTOM w0.508: v1(110.69,29.45) 110.59,29.35 C413.1 ; v1(114.64,26.65) 114.43,26.43 C421.2
VCC1.2O:
  vias: v1(113.09,26.78)
VCC_XD:
  vias: v1(20.99,21.42)
VCCDSW: length 2.5
  TOP w0.14: U16.83 149.4,25.26 TP23.1
VCCGI_SENSE: length 48.4
  IN3 w0.127: v1(86.48,91.61) 85.92,92.17 85.92,96.22 85.5,96.64 85.5,99.22 85.19,99.52 85.19,103.21 83.93,104.47 83.93,107.5 84.16,107.73 84.16,110.56 88.25,114.66 88.25,116.95 89.14,117.84 100.34,117.84 102.42,119.91 102.42,122.15 v1(102.93,122.66)
  BOTTOM w0.127: PR124.1 103.21,122.38 v1(102.93,122.66) ; U21.R41 86.36,91.61 v1(86.48,91.61)
VCCGISS_SENSE: length 50.5
  IN3 w0.127: v1(85.51,91.69) 85.51,94.57 85.02,95.06 85.02,97.26 85.27,97.5 85.27,98.96 84.3,99.92 84.3,102.92 82.9,104.32 82.9,108.56 83.65,109.31 83.65,110.77 87.73,114.85 87.73,117.16 88.92,118.36 100.13,118.36 101.9,120.13 101.9,123.38 102.35,123.83 103.01,123.83 v1(103.09,123.91)
  BOTTOM w0.127: v1(85.51,91.69) U21.R43 ; v1(103.09,123.91) 103.47,123.53 PR119.1
VCCRTC_2: length 287.8
  TOP w0.508: v1(182.4,17.09) v1(197.6,17.09) 200.74,17.09 v1(201.3,17.65)
  IN2 w0.508: v1(182.4,17.09) 181.42,16.11 178.29,16.11 176.36,18.04 176.36,21.84 173.18,25.02 v1(171.42,25.02) 167.78,25.02 165.62,22.87 155.62,22.87 154.45,24.03 153.9,24.03 153.26,24.67 148.83,24.67 147.79,25.7 142.88,25.7 142.56,26.02 141.97,26.02 141.59,25.64 132.08,25.64 131.15,26.58 121.99,26.58 121.93,26.52 121.49,26.52 116.49,21.52 114.25,21.52 113.8,21.07 113.8,18.83 113.37,18.39 107.78,18.39 107.18,18.99 91.99,18.99 91.5,19.47 82.85,19.47 79.09,15.7 74.07,15.7 72.57,14.2 46.8,14.2 45.4,15.6 42.77,15.6 42.15,16.23 40.41,16.23 39.5,17.13 39.5,21.33 38.62,22.21 v1(2.82,22.21)
  BOTTOM w0.508: R463.1 192.63,28.06 193.18,27.51 193.18,26.74 193.88,26.04 193.88,25.05 194.48,24.45 Q34.1 194.48,23.18 194.61,23.05 194.61,21.98 195.23,21.35 195.98,21.35 196.83,20.5 197.78,20.5 200.63,17.65 v1(201.3,17.65) ; CN7.1 160.07,48.86 160.45,49.23 163.56,49.23 171.42,41.38 v1(171.42,25.02) ; CN13.1 6.99,34.19 3.62,30.82 3.62,23.01 v1(2.82,22.21)
VCCRTC_3: length 5.4
  BOTTOM w0.127: v1(195.74,20.6) 195.21,20.6 193.82,22 Q34.3
  BOTTOM w0.508: Q34.3 193.22,22.77 193.01,22.77 R475.2
VCCRTC_4: length 1.8
  BOTTOM w0.508: R475.1 190.35,23.97 v1(190.22,23.83) 190.08,23.69 R474.2
VDD10: length 12.9
  TOP w0.203: U13.3 24.53,36.91 23.97,37.47 23.1,37.47 C189.2 ; U13.46 26.78,39.31 26.44,39.65 ; U13.8 24.5,34.91 24.41,34.83 23.18,34.83 22.89,34.54 C210.2 ; U13.20 28.78,31.7 v1(29.13,31.35) ; v1(32.66,36.51) U13.33
  TOP w0.381: v1(22.63,33.71) 22.63,34.54 C210.2 ; 26.44,39.65 25.32,40.77 ; C189.2 23.09,37.33 23.44,36.98 v1(23.79,36.98)
  TOP w0.508: v1(25.32,40) C177.2
  vias: v1(36.08,40.09) v2(34.54,41.7) v2(36.03,41.56) v2(36.03,40.8)
1P35V_CS: length 2.7
  BOTTOM w0.127: PR199.1 102.73,24.47 v1(102.45,24.19)
  BOTTOM w0.203: PU15.13 103.52,25.39 103.57,25.34 103.57,24.67 PR199.1
1P35V_FB: length 4.3
  BOTTOM w0.127: PR191.2 107.06,30.32 106.51,30.87 v1(106.51,31.02)
  BOTTOM w0.178: 105.86,28.67 105.61,28.41 PU15.6
  BOTTOM w0.203: PR192.1 106.57,28.77 105.96,28.77 105.86,28.67
  BOTTOM w0.254: PR192.1 107.06,29.25 PR191.2
1P35V_LGATE: length 9.9
  IN1 w0.762: v2(94.1,22.55) 94.31,22.76 100.9,22.76 102.18,24.04 v2(102.18,25.2)
  vias: v1(94.12,21.82)
1P35V_PGOOD: length 2.6
  BOTTOM w0.203: PU15.10 105.44,26.81 105.78,26.48 105.78,25.99 v1(105.9,25.87) PR196.2
1P35V_PHASE: length 2.9
  TOP w0.127: v1(92.11,26.73) PR52.1
  TOP w0.508: v2(93.64,27.56) 93.28,27.92 PR52.1
1P35V_S3: length 4.6
  TOP w0.127: v1(106.24,28.28) v1(105.57,28.28)
  TOP w0.203: PR53.2 PC41.1 v1(106.24,28.28)
  BOTTOM w0.178: v1(106.24,28.28) 105.93,28.28 105.67,28.01 PU15.7
  BOTTOM w0.203: PC41.1 v1(106.24,28.28)
1P35V_S5: length 8.7
  TOP w0.127: v1(108.65,27.21) PR53.1
  TOP w0.254: PR53.1 107.82,27.02 107.37,26.57 PC47.1 107.37,25.74 PR59.2 108.34,26.31 v1(108.19,26.46)
  BOTTOM w0.203: v1(108.19,26.46) 108.31,26.58 108.31,27.49 108.03,27.78 105.97,27.78 105.8,27.61 PU15.8
1P35V_TON: length 2
  BOTTOM w0.178: PU15.9 106.16,27.21 v1(106.23,27.28) 106.3,27.21 PR194.2
1P35V_UGATE: length 8.1
  IN1 w0.762: v2(93.64,29.14) 95.03,29.14 97.24,26.93 v2(100.83,26.93)
1P35V_VDD: length 2.6
  TOP w0.203: PR64.1 104.06,24.92 v1(104.06,25.11)
  BOTTOM w0.203: PU15.12 103.92,25.25 v1(104.06,25.11) 104.06,24.92 PR64.1
1P35V_VDDQ: length 3.9
  BOTTOM w0.203: PR190.1 104.84,30.43 105.04,30.23 v1(105.04,30.05) 104.89,29.9 104.66,29.9 104.32,29.56 PU15.5
  BOTTOM w0.254: PR191.1 105.85,30.21 105.15,30.91 PR190.1
1P35V_VID: length 3.5
  TOP w0.203: PR65.1 105.02,25.11 v1(104.72,25.11)
  BOTTOM w0.203: PU15.11 104.32,25.57 104.72,25.17 v1(104.72,25.11) 105.02,25.11 PR65.1
2ND_MBCLK: length 59.8
  TOP w0.127: v1(128.46,48.76) 129.14,48.08 129.14,45.59 131.48,43.26 135.25,43.26 v1(136.47,42.03) 138.03,40.48 R177.1 138.03,37.13 137.84,36.94 137.84,33.31 138.28,32.86 U16.115
  BOTTOM w0.127: U23.1 118.23,77.61 117.74,77.12 117.74,75.5 118.91,74.34 122.09,74.34 129.4,67.03 129.4,58.2 128.46,57.26 v1(128.46,48.76)
2ND_MBDATA: length 59.9
  TOP w0.127: v1(127.94,49.28) 127.94,48.55 128.62,47.87 128.62,45.38 131.26,42.73 135.03,42.73 136.94,40.83 v1(136.94,40.29) R176.1 136.94,36.19 137.59,35.53 137.59,33.21 137.88,32.92 U16.116
  BOTTOM w0.127: v1(127.94,49.28) 127.94,57.47 128.88,58.41 128.88,66.82 121.87,73.82 118.69,73.82 117.22,75.29 117.22,76.9 116.5,77.61 U23.5
680_LDO: length 116.5
  TOP w0.508: PR15.2 130.97,126.49 131.54,125.91 v1(132.02,125.91)
  IN1 w0.508: v1(149.75,53.17) 149.75,51.31 150.9,50.16 150.9,42.17 149.89,41.16 149.89,39.37 148.87,38.35 148.87,34.18 v1(149.7,33.35)
  IN2 w0.508: v1(149.75,53.17) 149.39,53.54 149.39,92.08 147.96,93.51 134.34,93.51 132.42,95.44 132.42,125.52 v1(132.02,125.91)
  BOTTOM w0.508: U30.1 148.51,34.8 148.67,34.96 C396.1 R450.1 v1(149.7,33.35)
8068EN_1.05V: length 3.1
  BOTTOM w0.14: PU8.5 125.99,108.27 125.86,108.4 125.86,108.85 126.22,109.2 PC140.1 PR142.2
8068FB_1.05V: length 4.6
  BOTTOM w0.165: PU8.6 129.69,108.27 129.83,108.41 v1(129.83,109.2) 129.3,109.73 PR143.1 128.9,110.73 PC137.2 PR141.2
8068FB_1.05V_S: length 13.5
  BOTTOM w0.165: PR141.1 PC137.1 128.39,112.02 125.68,112.02 v1(124.02,110.36) 123.26,109.61 123.26,109.28 122.73,108.75 119.11,108.75 PR146.2
8068LX_1.05V:
  vias: v1(126.07,101)
8068NC_1.05V: length 2.3
  BOTTOM w0.14: PU8.7 129.99,107.77 130.11,107.89 130.11,108.56 130.47,108.92 PC141.1
8068PG_1.05V: length 1.4
  BOTTOM w0.14: PU8.4 125.36,107.77 PR145.1
24707_LX: length 8.9
  IN1 w0.762: v2(46.46,20.82) 47.67,20.82 49.17,22.32 54.02,22.32 v2(54.56,21.78)
  vias: v1(53.58,21.95)
24737_ACDET: length 3.1
  TOP w0.254: PR67.2 39.82,22.25 39.92,22.35 40.56,22.35 PR68.2 40.66,21.33 41.02,20.97 PU2.6
24737_ACN: length 243.2
  TOP w0.14: v1(180.07,18.62) 180.07,17.35 180.58,16.85 181.39,16.85 181.69,16.55 213.04,16.55 213.94,17.45 213.94,19.84 214.72,20.62 214.72,22.1 214.35,22.48 214.35,23.17 211.47,26.05 211.47,28.3 212.59,29.43 217.32,29.43 218.01,30.12 219.3,30.12 219.59,30.41 219.59,30.61 PR45.1
  TOP w0.203: v1(129.8,38.81) 129.8,38.76 128.88,37.84 126.48,37.84 125.32,36.68 125.32,34.92 122.88,32.47 122.88,31.75 122.1,30.97 122.1,29.01 121.84,28.75 120.99,28.75 119.83,27.59 119.83,27.03 117.7,24.91 114.63,24.91 113.48,23.75 110.74,23.75 109.48,22.49 108.38,22.49 108.23,22.35 106.53,22.35 105.88,21.7 103.05,21.7 100.41,19.06 86.26,19.06 83.28,22.05 77.62,22.05 76.25,23.42 76.25,32.36 75.08,33.52 54.15,33.52 48.47,27.84 46.04,27.84 45.22,27.02 45.22,25.62 PC45.1 45.64,24.73 PC50.2 44.2,22.02 PU2.1
  IN2 w0.127: v1(180.07,18.62) 180.07,20.69 172.87,27.89 164.56,27.89 164.18,27.51 161.63,27.51 159.37,29.78 156.87,29.78 156.3,29.21 156.3,28.81 156.17,28.67 156.17,28.67 155.35,27.85 153.88,27.85 153.24,28.48 153.24,29.63 152.04,30.84 150.66,30.84 149.86,30.03 149.86,29.08 149.11,28.33 148.12,28.33 147.81,28.64 147.81,29.86 145.98,31.69 142.61,31.69 142.08,32.21 135.89,32.21 133.39,34.72 132.24,34.72 131.75,35.21 129.86,35.21 128.52,36.55 128.52,37.4 129.8,38.68 v1(129.8,38.81)
24737_ACP: length 244.5
  TOP w0.14: PR46.1 219.85,30.58 219.85,30.29 219.39,29.84 218.12,29.84 217.44,29.15 212.71,29.15 211.75,28.19 211.75,26.15 214.62,23.27 214.62,22.6 215,22.23 215,20.51 214.22,19.73 214.22,17.33 213.17,16.28 180.51,16.28 179.56,17.23 179.56,18.24 v1(179.31,18.5)
  TOP w0.203: v1(129.15,38.79) 129.15,38.57 128.75,38.17 126.21,38.17 124.98,36.94 124.98,35.06 122.53,32.62 122.53,31.89 121.75,31.11 121.75,29.23 121.61,29.08 120.42,29.08 118.01,26.67 118.01,25.77 117.49,25.25 114.49,25.25 113.32,24.08 110.52,24.08 109.27,22.83 108.23,22.83 108.09,22.69 106.39,22.69 105.73,22.03 102.9,22.03 100.27,19.4 86.41,19.4 83.42,22.39 77.76,22.39 76.59,23.56 76.59,32.5 75.23,33.86 54.01,33.86 48.33,28.18 45.9,28.18 44.88,27.16 44.88,25.62 PC46.2 44.22,24.55 44.44,24.33 PC50.1 44.44,22.89 43.7,22.15 PU2.2
  IN2 w0.127: v1(179.31,18.5) 179.31,21.09 172.76,27.64 164.66,27.64 164.28,27.26 161.52,27.26 159.26,29.52 156.97,29.52 156.56,29.11 156.56,27.8 156.28,27.53 153.84,27.53 152.99,28.38 152.99,29.52 151.93,30.58 150.77,30.58 150.11,29.92 150.11,28.97 149.22,28.08 148.01,28.08 147.56,28.54 147.56,29.75 145.87,31.43 142.51,31.43 141.98,31.96 135.79,31.96 133.28,34.46 132.13,34.46 131.64,34.95 129.76,34.95 128.26,36.44 128.26,37.51 129.15,38.39 v1(129.15,38.79)
24737_BM#: length 16
  TOP w0.254: v1(33.26,23.25) 33.26,23.22 32.79,22.75 PQ10.2 ; v1(40.89,17.29) 40.89,16.7 PR81.1 42.2,17.74 PU2.11
  IN1 w0.254: v1(33.26,23.25) 37.78,23.25 39.43,21.6 39.43,18.75 v1(40.89,17.29)
24737_BST: length 4
  TOP w0.127: PR72.1 47.43,18.66 v1(47.99,18.09)
  TOP w0.14: PU2.17 45.75,19.47
  TOP w0.381: PR72.1 45.98,19.24 45.75,19.47
24737_CMPIN: length 6.2
  TOP w0.254: PR54.2 41.47,26.69 41.18,26.4 41.18,24.89 41.53,24.53 PR61.2 41.8,23.77 PR66.1 42.18,23.21 42.7,22.69 PU2.4
24737_CMPOUT: length 9.7
  TOP w0.127: v1(43.98,28.99) PQ8.2
  TOP w0.254: PQ8.2 42.38,28.55 42.38,26.95 42.64,26.69 PR55.2 43.05,26.69 43.45,26.29 43.45,25.03 42.95,24.53 PR62.1 42.87,23.49 PR66.2 43.2,23.16 PU2.3
24737_DH: length 4.2
  IN1 w0.762: v2(46.32,19.89) 46.42,19.79 48.21,19.79 v2(49.8,21.38)
  vias: v1(49.42,21.95)
24737_DL: length 5.4
  IN1 w0.762: v1(50.04,17.08) 49.58,17.55 v2(44.79,17.55)
24737_ILIM: length 5.6
  TOP w0.254: PR80.1 39.85,16.46 v1(39.85,17.25) 39.85,17.98 PC58.2 40.35,18.07 v1(40.58,18.29) 40.58,18.57 40.99,18.97 PU2.10
  BOTTOM w0.254: PR201.2 39.91,17.89 PR200.2 40.3,18.29 v1(40.58,18.29)
24737_REGN: length 1.5
  TOP w0.127: v1(47.26,16.97) 46.69,17.54 PC59.1
  vias: v2(45.76,18.54)
24737_SRN: length 26
  TOP w0.152: v1(42.66,14.66) 42.47,14.47 42.37,14.47 42.08,14.18 PC62.2
  TOP w0.165: PC62.2 42.81,13.43 v1(42.81,13.39) 43.49,12.71 62.67,12.71 63.15,13.2 PR82.2 ; v1(42.66,14.66) 42.66,15.03 PC60.1
  BOTTOM w0.165: v1(42.66,14.66) 42.45,14.67 PR203.1
24737_SRP: length 24.6
  TOP w0.165: PR83.2 62.03,14.63 v1(62.03,13.85) 62.03,13.28 61.8,13.05 43.63,13.05 43.31,13.36 PC61.2 43.31,14.31 43.87,14.86 v1(44.21,14.86) 43.63,15.38 PC60.2
  BOTTOM w0.165: v1(44.21,14.86) 43.78,15.23 PR202.1
24737_VCC:
  vias: v1(46.32,22.26)
25810_AUO#: length 3.3
  TOP w0.254: R76.2 24.47,85.57 25.26,86.36 26.19,86.36 26.2,86.37 26.33,86.37 26.42,86.46 26.78,86.46 27.05,86.74 U3.17
25810_CC1: length 23.4
  TOP w0.14: CN1.A5 8.53,86.55 8.83,86.85 9.25,86.85 v1(9.67,87.27) ; U3.11 25.18,90.36 v1(25.03,90.51) 24.57,90.51 24.47,90.4 21.39,90.4 20.51,91.29 17.73,91.29 16.39,89.95 16.39,89.57 ESD1.3 16.39,89.06 16.39,88.71 v1(15.77,88.09)
  IN3 w0.14: v1(9.67,87.27) 9.81,87.13 10.64,87.13 12.55,89.04 15.08,89.04 15.77,88.35 v1(15.77,88.09)
25810_CC2: length 37
  TOP w0.14: U3.13 24.35,89.36 v1(24.14,89.57) 23.58,90.13 21.28,90.13 20.39,91.01 17.84,91.01 17.12,90.29 17.12,88.69 16.83,88.39 16.83,87.28 16.39,86.84 16.39,86.57 ESD1.4 16.44,86.11 16.44,85.81 16.36,85.73 16.19,85.73 16.12,85.81 16.12,86.97 16.27,87.12 v1(16.27,87.69)
  IN3 w0.14: CN1.B5 4.21,86.04 4.21,90.28 4.77,90.85 8.68,90.85 10.21,89.31 15.19,89.31 16.05,88.45 16.05,88.45 16.27,88.24 v1(16.27,87.69)
25810_DBG#: length 2.3
  TOP w0.254: U3.16 25.92,87.86 25.46,87.4 v1(25.46,87.05) 25.12,87.05 24.63,86.57 R65.2
25810_FAULT#: length 3.5
  TOP w0.254: R69.2 R68.2 30.96,86.65 30.8,86.81 30.8,87.33 v1(30.56,87.58) 30.28,87.86 U3.1
25810_LD_DET#: length 2.4
  TOP w0.254: R80.2 29.65,86.29 v1(29.58,86.37) 28.69,86.37 28.55,86.5 U3.20
25810_POL#: length 2.7
  TOP w0.254: U3.18 27.55,86.26 27.32,86.03 27.01,86.03 v1(26.78,85.81) 26.17,85.81 25.94,85.57 R77.2
25810_REF: length 2.2
  TOP w0.254: R48.2 26.63,92.79 26.5,92.66 v1(26.5,92.36) 26.5,92.08 27.05,91.53 U3.10
25810_REF_RTN: length 4.2
  TOP w0.127: v1(26.83,94.85) 26.83,94.19 26.63,93.99 R48.1
  TOP w0.254: R48.1 26.87,93.94 27.16,93.66 27.16,92.16 27.55,91.77 U3.9
25810_UFP#: length 5.8
  TOP w0.254: U3.19 28.05,86.39 28.69,85.75 R79.2 R78.2 27.36,85.56 26.78,84.98 v1(26.78,84.28) 26.78,83.63 Q6.2
25810_UFP#_G1: length 6.7
  TOP w0.127: Q8.2 29.23,77.54 v1(29.5,77.27)
  TOP w0.254: Q6.3 Q8.2 29.68,79.51 30.44,78.74 R96.2
25810_UFP#_G2: length 5.6
  TOP w0.381: Q7.4 25.49,80.09 25.62,79.96 R94.2 25.98,79.51 26.24,79.24 26.24,78.07 26.99,77.33 v1(26.99,77.25) 27.98,77.25 Q8.3
61087COMP: length 2.9
  TOP w0.254: PU1.1 54.08,128.22 54.32,128.45 v1(55.49,128.45) 55.74,128.71 PR10.2
61087EN: length 17.7
  TOP w0.127: v1(50.76,129.39) 50.76,128.68 v1(50.58,128.5)
  TOP w0.254: PU1.3 53.08,128.89 PC7.2 PR7.2 v1(50.76,129.39) ; PR28.2 58.89,124.02 58.89,128.38 v1(58.3,128.97)
  BOTTOM w0.254: v1(50.76,129.39) 51.18,128.97 v1(58.3,128.97)
61087FB: length 2.6
  TOP w0.254: PR9.1 53.68,129.39 PR8.2 53.59,129.3 PU1.2
61087FREQ: length 5.1
  TOP w0.254: PR29.1 56.91,124.2 PR25.2 56,124.2 v1(55.89,124.31) 55.56,123.98 54.08,123.98 53.59,124.48 PU1.9
61087SS: length 4.6
  TOP w0.127: v1(56.91,126.11) PC16.2
  TOP w0.254: PC16.2 55.71,125.16 54.93,124.38 54.26,124.38 54.08,124.56 PU1.10
61087SW:
  vias: v1(51.37,117.78)
+601_VCC: length 5
  TOP w0.381: v1(207.79,42.31) 207.39,41.91 R171.1 ; R218.1 203.02,33.76 204.86,33.76 205.29,33.33 v1(205.52,33.33)
  TOP w0.508: R170.1 210.17,42.24 209.92,42.49 v1(209.31,42.49)
  vias: v1(202.6,40.07) v1(203.27,40.07) v1(203.93,40.07) v1(209.74,34.12) v1(209.76,35.04) v1(210.56,35.03)
+AZA_VDD:
  vias: v1(194.17,32.67) v1(194.75,32.03) v1(195.29,32.42) v1(205.37,29.55) v1(206.06,29.52)
+SMDDR_VREF_CA_A: length 74.5
  TOP w0.508: 62.14,49.5 62.14,49.71 63.2,50.77 68.42,50.77 68.61,50.97 70.23,50.97 71.16,50.03 ; R144.1 R146.2 C139.2 C141.1 C146.1 48.25,55.22 49.86,53.61 v1(50.73,53.61) 50.99,53.61 52.04,52.55 52.04,50.87 53.11,49.81 v1(53.46,49.81)
  IN3 w0.508: v1(72.9,49.88) 72.9,40.7 74.25,39.34 77.17,39.34 80.45,42.62 80.45,49.08 v1(80.05,49.48) ; v1(60.57,49.83) 60.16,49.42 60.16,40.36 58.96,39.16 56.63,39.16 53.17,42.62 53.17,49.51 v1(53.46,49.81)
+SMDDR_VREF_CA_B: length 67.7
  TOP w0.508: v1(115.23,49.48) 116.2,49.48 116.45,49.23 C163.1 C165.1 C167.2 R164.2 R166.1 ; 97.21,50.06 97.98,50.83 v1(100.89,50.83) 100.97,50.75 103.43,50.75 103.88,51.2 104.6,51.2 106.3,49.5
  IN3 w0.508: v1(88.64,49.81) 88.29,49.45 88.29,42.77 91.72,39.33 93.95,39.33 94.76,40.14 94.76,46.65 94.88,46.77 94.88,48.98 v1(95.75,49.84) ; v1(108.09,49.89) 108.97,49.02 108.97,44.2 108.84,44.07 108.84,40.24 109.42,39.66 112.23,39.66 113.33,40.76 113.33,43.97 115.47,46.11 115.47,49.24 v1(115.23,49.48)
+SMDDR_VREF_DQ_A: length 80.9
  TOP w0.305: 53.53,52.48 54.37,52.48 U8.H1 ; v1(72.1,52.25) 72.48,52.63 U9.H1
  TOP w0.508: v1(53.65,51.14) 53.53,51.27 53.53,52.48 53.53,52.48 53.53,53.3 v1(51.88,54.96) 51.26,55.58 C147.1 C142.1 C140.2 R147.2 R145.1
  IN2 w0.381: v1(61.38,52.25) 61.57,52.25 63.91,54.59 69.58,54.59 71.69,52.48 71.88,52.48 v1(72.1,52.25)
  IN3 w0.508: v1(61.38,52.25) 61.38,51.36 60.76,50.74 60.09,50.74 58.95,49.6 58.95,40.95 58.42,40.42 57.13,40.42 56.57,40.97 56.57,48.92 55.13,50.36 54.44,50.36 v1(53.65,51.14) ; v1(72.1,52.25) 72.1,51.44 72.7,50.84 73.48,50.84 74.17,50.16 74.17,41.28 74.96,40.48 76.26,40.48 78.5,42.72 78.5,49.85 78.99,50.34 v1(79.41,50.34)
  BOTTOM w0.305: U24.H1 61.38,52.27 v1(61.38,52.25) ; U25.H1 79.41,52.15 v1(79.41,50.34)
+SMDDR_VREF_DQ_B: length 79.4
  TOP w0.305: U10.H1 88.83,51.76 v1(88.83,51.14) ; v1(107.27,52.26) 107.45,52.44 107.45,52.48 U11.H1
  TOP w0.508: v1(114.7,51.14) 114.95,51.4 115.88,51.4 v1(116.67,52.18) 117.02,52.53 C156.1 C152.1 C149.2 R150.2 R148.1
  IN2 w0.508: v1(96.56,52.25) 96.74,52.25 99.16,54.67 104.71,54.67 106.88,52.49 107.04,52.49 v1(107.27,52.26)
  IN3 w0.508: v1(96.56,52.25) 96.56,51.48 95.98,50.89 95.15,50.89 93.99,49.74 93.99,47.24 93.87,47.11 93.87,40.86 93.46,40.45 92.37,40.45 90.36,42.46 90.36,49.62 v1(88.83,51.14) ; v1(107.27,52.26) 107.27,51.45 107.83,50.89 108.89,50.89 109.73,50.05 109.73,40.94 110.15,40.52 111.83,40.52 112.44,41.13 112.44,48.54 114.7,50.8 v1(114.7,51.14)
  BOTTOM w0.305: U27.H1 114.7,52.04 v1(114.7,51.14) ; v1(96.56,52.25) 96.56,52.27 U26.H1
+TPVDD: length 1.6
  TOP w0.508: ESD4.5 110.6,18.14 110.48,18.27 v1(110.48,19.1)
  vias: v1(116.9,20.45) v2(115.12,19.39) v2(115.7,19.87)
+TYPEC_VBUS: length 2.6
  TOP w0.254: CN1.A9 6.59,84.55 6.54,84.6 CN1.B4 ; CN1.B9 6.45,87 6.5,87.05 CN1.A4
  vias: v1(15.53,85.63) v1(22.39,80.24) v2(10.56,89.89) v2(11.51,89.86) v2(23.98,79.8) v2(23.98,79.03) v2(23.98,78.27)
+TYPEC_VBUS_C:
  vias: v1(22.19,85.83)
+VNN: length 103.8
  TOP w0.254: PC23.1 81.66,123.95 84.7,126.98 84.7,136.89 86.07,138.26 97.65,138.26 100.56,135.35 111.84,135.35 114.37,132.82 v1(114.51,132.82)
  BOTTOM w0.203: PL2.2 77.33,125.18 77.66,125.51 82.74,125.51 84.64,127.41 84.64,137.25 85.93,138.54 99.94,138.54 103.34,135.13 110.41,135.13 112.08,133.46 112.08,133.21 PR94.2
  BOTTOM w0.254: PR95.1 114.79,133.12 114.51,132.84 v1(114.51,132.82)
  BOTTOM w0.305: U21.AM25 93.37,83.9 v1(93.75,83.53) 94.13,83.9 U21.AM23
  vias: v1(80.12,123.32) v1(80.79,110.34) v1(81.47,110.33) v1(81.76,109.73) v1(82.12,110.3) v1(82.18,109.19) v1(84.3,84.99) v1(84.28,84.26) v1(85.08,84.99) v1(85.08,84.26) v1(85.88,84.99) v1(85.86,84.26) v1(86.64,84.26) v1(86.66,84.98) v1(87.44,85.71) v1(92.94,82.75) v2(78.83,119.64) v2(79.59,121.54) v2(79.59,120.48) v2(79.72,122.48) v2(79.67,118.72) v2(80.17,119.56) v2(80.66,121.47) v2(80.66,120.38) v2(80.71,118.32)
+WL_VDD:
  vias: v1(160.01,45.29) v1(160.01,44.66) v1(160.77,45.29) v1(160.77,44.66) v1(161.91,25.86) v1(162.55,25.86) v1(167.63,30.56) v1(169.38,29.77)
AC_PROTECT: length 138.9
  TOP w0.14: U16.95 145.28,30.06 v1(144.45,29.24) ; PR55.1 43.97,28.49 48.2,28.49 53.88,34.17 75.36,34.17 76.9,32.63 76.9,23.69 77.89,22.7 83.55,22.7 86.54,19.71 100.14,19.71 102.77,22.34 105.6,22.34 106.26,23 107.96,23 108.1,23.14 109.14,23.14 110.39,24.39 113.19,24.39 114.36,25.56 117.36,25.56 117.7,25.89 117.7,26.8 120.17,29.27 120.17,29.82 120.93,30.57 120.93,32.46 121.52,33.06 122.53,33.06 124.67,35.19 124.67,37.07 126.06,38.47 128.2,38.47 v1(128.5,38.78)
  IN2 w0.127: v1(144.45,29.24) 142.77,29.24 141.66,30.35 136.98,30.35 136.24,31.09 135.58,31.09 133.7,32.97 128.52,32.97 127.23,34.25 126.62,34.25 126.49,34.39 126.49,36.09 128.5,38.11 v1(128.5,38.78)
ACCEL_INT1: length 9.1
  TOP w0.14: D7.1 162.8,22.74 164.78,24.73 164.78,25.76 164.45,26.09 v1(163.94,26.09) 163.82,26.22 C242.2 Q19.5
ACCEL_INT1_R: length 14.8
  TOP w0.203: 151.86,16.96 151.61,17.21 151.61,18.23 151.85,18.47 151.85,19.61 152.17,19.93 154.02,19.93 v1(157.07,22.98) 157.36,22.98 157.59,22.74 D7.2
  TOP w0.305: U17.11 153.66,15.17 151.86,16.96
ACCEL_INT2: length 87.2
  TOP w0.254: v1(166.92,28.35) v1(166.92,27.23) 166.92,26.41 161.48,20.96 D8.1 ; R242.1 226.06,27.4 v1(225.69,27.78)
  IN1 w0.254: v1(224.63,20.38) 224.63,19.82 223.33,18.52 215.36,18.52 213.41,16.57 181.47,16.57 180.92,17.12 178.98,17.12 178.01,18.09 178.01,22.53 176.62,23.93 170.96,23.93 166.92,27.98 v1(166.92,28.35)
  BOTTOM w0.254: v1(225.69,27.78) 225.69,26.74 225.98,26.45 ; 225.98,26.45 225.84,26.31 225.84,21.98 224.63,20.76 v1(224.63,20.38) ; 225.98,26.45 CN12.13
ACCEL_INT2_R: length 12
  TOP w0.203: D8.2 157.36,20.96 v1(156.78,21.55) 156.27,21.55 154.32,19.6 152.31,19.6 152.25,19.54 152.25,18.41
  TOP w0.305: U17.9 154.49,16.17 152.25,18.41
ACCEL_INTA: length 143.7
  TOP w0.14: v1(129.76,45.71) 129.97,45.5 133.02,45.5 133.3,45.22 137.3,45.22 138.11,46.03 149.93,46.03 156.42,39.55 157.32,39.55 158.61,38.26 v1(161.38,38.26) 161.46,38.26 164.33,35.39 164.33,34.33 165.55,33.12 165.55,27.81 165.2,27.46 164.73,27.46 164.47,27.72 Q19.6
  IN1 w0.102: v1(96.51,105.11) 97.56,104.05 101.76,104.05 104.23,101.58 108.11,101.58 109.38,100.32 111.15,100.32 116.21,95.26 116.21,88.64 123.51,81.34 123.51,68.74 125.5,66.75 125.5,49.99 124.46,48.95 124.46,46.72 125.48,45.71 v1(129.76,45.71)
  BOTTOM w0.102: U21.B31 90.84,97.89 90.84,98.92 91.55,99.63 92.6,99.63 92.75,99.79 94.08,99.79 95.07,100.78 95.63,100.78 95.85,101 95.85,102.54 95.49,102.91 95.49,102.98
  BOTTOM w0.127: R321.2 95.49,102.98
  BOTTOM w0.14: R321.2 96,103.84 96,104.61 v1(96.51,105.11)
ACIN: length 161.6
  TOP w0.14: v1(127.63,36.39) 126.4,36.39 125.63,35.63 125.63,34.79 123.19,32.34 123.19,31.62 122.41,30.84 122.41,28.88 121.98,28.45 121.13,28.45 120.14,27.46 120.14,26.9 117.83,24.59 114.76,24.59 113.61,23.44 110.87,23.44 109.61,22.18 108.5,22.18 108.36,22.03 106.66,22.03 106.02,21.39 103.23,21.39 97.24,15.4 84.54,15.4 81.54,12.4 73.45,12.4 73.14,12.72 73.14,15.88 72.02,16.99 67.94,16.99 65.84,14.9 65.84,13.51 64.76,12.42 41.01,12.42 39.03,14.4 39.03,17.09 38.73,17.39 36.65,17.39 33.83,20.21 33.83,22.87 34.15,23.19 35.9,23.19 36.03,23.32 36.03,24.57 36.16,24.7 PR63.1 36.91,24.29 PQ9.3 ; U16.72 146.38,20.86 145.81,20.29 143.97,20.29 143.53,20.73 143.53,21.55 144.91,22.93 144.91,23.91 143.31,25.5 143.31,28.92 v1(145.12,30.73)
  IN2 w0.127: v1(127.63,36.39) 127.96,36.39 129.34,35.01 129.34,34.91 130.41,33.84 130.86,33.84 131.14,34.11 133.27,34.11 135.68,31.71 141.38,31.71 141.91,31.18 144.67,31.18 v1(145.12,30.73)
ACPRESENT: length 16.4
  TOP w0.127: R85.1 v1(71,83.01)
  TOP w0.14: v1(82.54,85.02) 82.44,85.02 81.97,84.55 80.95,84.55 80.47,84.07 80.47,83.78 79.46,82.78 78.73,82.78 78.04,82.09 75.82,82.09 74.43,83.47 71.46,83.47 v1(71,83.01) ; R88.2 R85.1
  BOTTOM w0.102: v1(82.54,85.02) 82.18,84.67 U21.AK49
ADOGND: length 25.5
  TOP w0.203: v1(204.13,30.79) 204.13,30.71 203.69,30.28 U15.38
  TOP w0.381: v1(205.83,31.81) 205.27,31.81 205.17,31.91 R227.2 204.8,31.91 204.56,32.15 204.56,32.31 204.13,32.75 203.58,32.75 C220.2 ; C223.1 v1(208.04,31.42) ; C260.1 212.33,23.4 v1(211.87,23.86) ; R239.2 v1(209.65,30.25)
  TOP w0.508: v1(210.04,28.09) 210.31,27.82 C243.1 ; C259.2 208.53,23.83 v1(208.77,23.83) ; R235.2 209.04,31.41 v1(208.8,31.65) ; C255.2 206.98,24.59 v1(206.71,24.32) ; C249.1 208.15,25.73 v1(208.79,25.09) ; v1(211.87,23.86) v1(211.4,24.33) 211.14,24.59 R251.1
  BOTTOM w0.305: CN17.30 v1(209.35,19.21) ; CN17.23 v1(212.85,19.22) ; CN17.34 v1(207.35,19.31) ; CN17.32 208.35,19.3 v1(208.34,19.31)
  BOTTOM w0.381: C442.1 203.62,20.37 v1(204.13,20.37) 204.68,20.37 C443.2 ; C436.1 199.15,22.03 199.15,20.83 v1(199.58,20.4) 200.22,20.4 C441.1
  BOTTOM w0.508: C243.1 210.31,27.82 v1(210.04,28.09) ; R479.2 202.3,19.29 v1(201.81,19.78) ; C428.2 208.35,23.83 v1(208.77,23.83) ; R473.2 204.72,23.83 v1(204.74,23.85)
ALERT#: length 1.9
  BOTTOM w0.14: U23.3 TP39.1
AMP_MUTE#: length 68.2
  TOP w0.14: v1(143.4,30.61) 142.94,30.14 141.89,30.14 141.08,30.96 U16.108
  IN3 w0.127: v1(184.06,21.75) 184.06,21.8 183.34,22.52 178.06,22.52 168.55,32.03 163.14,32.03 162.2,32.96 160.17,32.96 159.62,32.4 156.32,32.4 156.31,32.41 156.31,32.43 156.01,32.73 153.95,32.73 153.36,32.14 152.09,30.88 146.44,30.88 146.01,31.31 144.1,31.31 v1(143.4,30.61)
  BOTTOM w0.127: D22.1 v1(192.19,31.27) 191.82,31.27 189.64,29.09 187.13,29.09 183.15,25.1 183.15,22.92 184.06,22.01 v1(184.06,21.75)
ASM_XIN: length 7.7
  BOTTOM w0.127: Y4.1 121.69,38.27 121.84,38.12 121.84,35.56 C395.2 121.75,35.13 121.75,34.81 121.53,34.59 120.88,34.59 v1(120.33,34.04) 120.33,33.44 120.04,33.14 U32.25
ASM_XOUT: length 7.7
  BOTTOM w0.127: U32.26 120.23,32.74 120.78,33.3 120.78,33.86 121.1,34.18 v1(121.7,34.18) 122.21,34.69 122.21,35.15 C395.1 122.18,35.48 122.18,37.18 122.28,37.28 122.43,37.28 Y4.3
AZ_CODEC_BITCLK: length 219.9
  TOP w0.127: R98.1 68.23,78.74 64.39,78.74 63.36,77.71 v1(62.42,77.71) ; U15.6 197.67,26.8 196.96,26.09 C247.2 194.53,26.29 v1(194.1,26.72)
  IN1 w0.102: v1(62.42,77.71) 62.42,75.86 59.82,73.27 48.97,62.41 46.02,62.41 43.64,60.04 43.64,51.2 v1(50.5,44.34)
  IN3 w0.127: v1(194.1,26.72) 193.93,26.89 192.88,26.89 191.4,25.42 188.37,25.42 188.07,25.72 180.52,25.72 168.41,37.84 154.58,37.84 153.6,38.82 152.19,38.82 150.94,40.07 150.56,40.07 149.64,41 136.42,41 134.67,42.75 130.09,42.75 128.68,44.16 117.84,44.16 116.34,42.66 116.34,41.96 112.76,38.38 105.93,38.38 105.1,39.2 96.14,39.2 94.38,37.44 91.74,37.44 90.94,38.23 79.53,38.23 78.78,37.48 73.69,37.48 72.22,38.95 62.48,38.95 61.02,37.49 56.34,37.49 51.69,42.13 51.69,43.15 v1(50.5,44.34)
AZ_CODEC_RST#: length 284.5
  TOP w0.127: R52.1 67.78,93.43 v1(67.5,93.15) ; v1(183.53,21.29) 183.53,22.2 183.95,22.62 190.47,22.62 191.08,23.23 v1(193.2,23.23) 195.12,23.23 195.89,22.46 197.69,22.46 197.98,22.74 197.98,24.48 198.3,24.8 U15.11
  IN3 w0.127: v1(183.53,21.29) 183.53,21.57 183.09,22.01 177.83,22.01 168.33,31.51 162.94,31.51 162,32.44 160.39,32.44 159.84,31.9 156.13,31.9 155.8,32.22 154.16,32.22 153.87,31.93 152.22,30.28 144.06,30.28 143.85,30.07 137.62,30.07 136.93,30.77 134.48,30.77 133.49,31.76 129.91,31.76 129.4,32.27 128.67,32.27 127.34,33.61 124.71,33.61 122.86,31.75 120.05,31.75 118.79,30.5 114.32,30.5 114.14,30.68 111.95,30.68 111.68,30.4 109.65,30.4 109.19,29.93 108.06,29.93 107.37,29.24 107.07,28.95 107.07,28.43 106.31,27.66 105.92,27.66 105.18,26.92 105.18,24 104.26,23.09 103.76,23.09 101.17,20.5 94.15,20.5 93.29,21.35 85.42,21.35 84.3,22.47 66.87,22.47 64.76,24.59 64.76,29.16 64.17,29.75 52.16,29.75 41.85,40.05 41.85,75.12 46.97,80.24 46.97,84 50.15,87.18 55.18,87.18 55.59,86.77 61.68,86.77 62.34,87.43 63.94,87.43 64.88,88.37 64.88,91.95 65.24,92.31 66.66,92.31 v1(67.5,93.15)
  BOTTOM w0.127: v1(183.53,21.29) 183.53,21.82 182.64,22.71 182.64,25.35 186.9,29.62 189.45,29.62 192.16,32.33 193.48,32.33 193.68,32.53 193.68,34.32 Q32.1
AZ_CODEC_SDIN0: length 225.2
  TOP w0.127: R249.1 193.64,24.82 v1(193.22,25.24)
  IN3 w0.127: v1(81.82,84.08) 81.17,83.44 80.42,83.44 79.94,82.96 74.38,82.96 73.96,82.54 72.79,82.54 72.13,81.87 72.13,80.66 71.23,79.76 71.16,79.76 70.81,79.41 69.74,79.41 69.32,79 64.35,79 59.33,73.97 58.37,73.97 48.33,63.94 48.33,47.52 49.88,45.97 49.88,43.49 50.65,42.71 50.65,41.7 55.89,36.46 79.2,36.46 79.95,37.22 90.52,37.22 91.31,36.42 94.84,36.42 96.58,38.16 104.71,38.16 105.5,37.36 113.18,37.36 118.93,43.12 128.25,43.12 129.64,41.72 134.23,41.72 136.36,39.59 149.58,39.59 150.84,38.33 150.84,37.18 151.6,36.42 154.59,36.42 154.99,36.82 167.99,36.82 180.1,24.71 187.65,24.71 188.33,24.02 191.99,24.02 v1(193.22,25.24)
  BOTTOM w0.127: v1(81.82,84.08) 81.47,84.43 U21.AK51
AZ_CODEC_SDOUT: length 219
  TOP w0.127: R95.1 68.88,79.26 63.97,79.26 v1(63.33,78.62) ; U15.5 197.4,27.2 C245.1 196.28,27.14 195.45,27.14 v1(195.41,27.18)
  IN1 w0.102: v1(52.21,42.57) 52.21,43.33 44.13,51.41 44.13,59.83 46.22,61.92 49.17,61.92 63.33,76.08 v1(63.33,78.62)
  IN3 w0.127: v1(195.41,27.18) 195.13,27.47 192.73,27.47 191.19,25.93 188.58,25.93 188.28,26.23 180.73,26.23 168.62,38.35 154.79,38.35 153.81,39.32 152.41,39.32 151.15,40.58 150.77,40.58 149.85,41.5 136.65,41.5 134.9,43.26 130.32,43.26 128.9,44.68 119.81,44.68 119.42,45.07 118.03,45.07 115.84,42.87 115.84,42.18 112.55,38.89 106.24,38.89 105.41,39.72 95.95,39.72 94.17,37.95 91.95,37.95 91.15,38.74 79.32,38.74 78.57,37.98 73.9,37.98 72.42,39.47 62.28,39.47 60.83,38.01 56.53,38.01 52.21,42.33 v1(52.21,42.57)
AZ_CODEC_SYNC: length 212.7
  TOP w0.127: v1(197.56,24.26) 197.56,24.58 198.18,25.2 U15.10
  IN1 w0.102: v1(57.05,71.91) 48.05,62.91 45.81,62.91 43.14,60.24 43.14,50.96 v1(50.4,43.71)
  IN3 w0.127: v1(197.56,24.26) 197.56,25.49 196.98,26.07 194.55,26.07 194.29,25.81 193.07,25.81 192.16,24.91 188.16,24.91 187.86,25.21 180.31,25.21 168.2,37.33 154.78,37.33 154.38,36.93 153.36,36.93 150.73,39.57 150.33,39.57 149.41,40.49 136.2,40.49 134.44,42.24 129.86,42.24 128.46,43.64 118.73,43.64 112.97,37.87 105.71,37.87 104.9,38.68 96.36,38.68 94.61,36.93 91.52,36.93 90.73,37.72 79.74,37.72 78.99,36.97 73.48,36.97 72.02,38.43 62.68,38.43 61.22,36.97 56.12,36.97 51.17,41.92 51.17,42.93 v1(50.4,43.71)
  BOTTOM w0.127: R399.1 62.05,75.09 58.87,71.91 v1(57.05,71.91)
AZ_SDIN0_R: length 5.7
  TOP w0.127: U15.8 198.12,26 197.19,25.07 195.24,25.07 194.98,24.82 R249.2 v1(194.53,23.92)
BAT-V: length 3.4
  TOP w0.152: PR78.2 62.85,18.12 62.71,17.99 62.71,15.88 PR82.1
  vias: v1(66,26.98) v1(67.3,22.18) v2(67.74,23.68) v2(68.12,20.75) v2(68.56,23.72) v2(68.97,20.78) v2(69.45,23.72) v2(69.87,20.82) v2(70.38,23.69) v2(70.77,20.82)
BATLED0#: length 96.6
  TOP w0.127: v1(132.58,19.12) 132.44,19.26 U16.29
  IN1 w0.102: v1(132.58,19.12) 133.2,19.12 133.77,18.55 133.77,17.71 135.8,15.68 148.61,15.68 150.68,17.75 150.68,17.75 150.76,17.83 150.76,18.34 152.06,19.64 155.01,19.64 155.62,20.25 164.6,20.25 165.77,19.08 175.55,19.08 178.85,15.78 181.3,15.78 181.89,15.19 212.28,15.19 v1(212.89,15.8)
  BOTTOM w0.14: CN17.10 219.35,16.46 218.39,15.51 213.19,15.51 v1(212.89,15.8)
BATLED1#: length 100.7
  TOP w0.127: U16.25 133.47,20.86 v1(134.86,22.26)
  IN3 w0.127: v1(212.84,13.37) 212.4,12.93 188.22,12.93 181.33,19.82 174.17,19.82 171.31,22.69 154.59,22.69 152.55,20.65 147.06,20.65 146.07,21.63 140.49,21.63 139.69,22.43 135.04,22.43 v1(134.86,22.26)
  BOTTOM w0.14: v1(212.84,13.37) 211.73,14.48 211.73,16.14 212.06,16.46 213.55,16.46 214.02,15.99 218.49,15.99 219.06,16.57 219.06,17.34 218.85,17.55 CN17.11
BEEP_1: length 4.2
  TOP w0.127: v1(194.53,19.68) C268.2
  TOP w0.14: R255.1 C268.2 R262.2 C264.2
BI#: length 71.1
  TOP w0.14: v1(71.68,20.87) 72.12,20.43 PR77.2
  IN1 w0.102: v1(128.95,31.27) 128.83,31.3 126.84,33.29 125.17,33.29 122.4,30.52 120.78,30.52 116.53,26.27 116.09,26.27 111.57,21.76 103.7,21.76 102.24,20.29 91.26,20.29 90.72,20.83 85.35,20.83 83.79,22.39 73.2,22.39 v1(71.68,20.87)
  BOTTOM w0.127: v1(71.68,20.87) 71.59,20.96 PJ5.6
  BOTTOM w0.14: SW2.1 SW2.2 128.92,31.3 v1(128.95,31.27)
BI_GATE: length 44.9
  IN2 w0.254: v1(136.62,34.28) 135.87,35.03 132.37,35.03 131.88,35.53 130.5,35.53 v1(129.68,36.34)
  BOTTOM w0.254: SW1.4 SW1.3 141.65,28.8 142.27,29.42 143.75,29.42 144.01,29.68 C384.1 146.16,29.93 146.67,30.43 R446.1 146.66,31.19 145.47,32.38 145.47,32.41 145.32,32.56 144.08,32.56 143.79,32.85 140.19,32.85 139.94,33.1 139.94,33.48 139.14,34.28 v1(136.62,34.28) ; v1(129.68,36.34) 128.83,36.34 128.1,37.07 127.38,37.07 126.62,36.32 Q31.2 125.59,34.56 125.59,33.09 126.09,32.59 128.98,32.59 129.25,32.31 Q33.5
BL#: length 5
  TOP w0.279: R11.1 43.67,106.63 v1(44.26,107.22) 45.02,107.22 45.6,106.63 Q3.2 46.71,106.63 46.81,106.53 46.81,106.11 46.69,105.98 Q3.3
BL_ON: length 26.4
  TOP w0.14: v1(49.44,115.57) 49.44,112.45 48.73,111.74 Q2.3 48.12,110.39 48.04,110.31 D1.2 48.04,109.22 48,109.18 R7.1 48.45,107.96 48.45,107.4 48.34,107.28 Q3.6
  BOTTOM w0.14: CN3.26 60.13,122.95 60.04,122.87 59.62,122.87 59.39,122.64 59.39,119.04 57.68,117.32 53.29,117.32 51.54,115.57 v1(49.44,115.57)
BOARD_ID0: length 5.7
  BOTTOM w0.102: 88.59,102.98 R339.2 88.12,101.62 88.12,100.45 87.42,99.74 U21.A38
  BOTTOM w0.14: R316.1 88.59,102.98
BOARD_ID1: length 8.5
  BOTTOM w0.102: U21.B33 89.76,97.73 89.76,99.34 90.51,100.09 91.13,100.09 91.53,100.49 92.2,100.49 92.41,100.7 92.8,100.7 93.03,100.94 93.03,101.46 93.53,101.95 R341.2 93.53,102.5 94,102.98
  BOTTOM w0.127: R320.1 94,102.98
BOARD_ID2: length 6.8
  BOTTOM w0.102: U21.C39 86.96,97.3 87.25,97.59 87.25,97.84 87.1,97.99 87.1,101.54 R348.2 87.63,102.98
  BOTTOM w0.14: R315.1 87.63,102.98
BOARD_ID3: length 6.1
  BOTTOM w0.102: U21.B39 86.89,97.78 86.89,98.95 86.19,99.65 86.19,101.6 R347.2 86.67,102.98
  BOTTOM w0.127: R314.1 86.67,102.98
BOARD_ID4: length 7.5
  BOTTOM w0.102: 91.12,102.98 90.99,102.85 90.99,101.77 R349.2 90.89,100.71 90.27,100.71 88.92,99.36 88.92,97.82 U21.B35
  BOTTOM w0.127: R319.1 91.12,102.98
BOARD_ID5: length 7.6
  BOTTOM w0.102: U21.A34 89.27,99.43 90.34,100.5 90.96,100.5 91.36,100.9 92.03,100.9 R342.2 92.43,101.43 92.83,101.83 92.83,102.32 92.43,102.72 92.43,102.98
  BOTTOM w0.127: R309.1 92.43,102.98
BOARD_ID6: length 30.7
  IN2 w0.127: v1(96.12,110.07) 95.52,110.68 91.78,110.68 91.27,111.18 89.26,111.18 87.27,109.19 87.27,103.11 87.95,102.42 87.95,99.65 87.4,99.1 87.4,95.82 87.87,95.35 87.87,94.9 v1(87.43,94.46)
  BOTTOM w0.102: v1(87.43,94.46) 87.26,94.46 U21.H39
  BOTTOM w0.127: R296.1 R288.2 97.2,109.1 97.2,110.26 96.94,110.52 96.57,110.52 v1(96.12,110.07)
BOARD_ID7: length 18.2
  IN2 w0.127: v1(91.29,98.61) 91.19,98.71 91.19,100.26 88.03,103.42 88.03,108.87 88.8,109.64 90.25,109.64 v1(90.7,110.09)
  BOTTOM w0.102: v1(91.29,98.61) 91.13,98.45 U21.A30
  BOTTOM w0.127: R290.1 R282.2 90.46,108.66 90.9,109.1 90.9,109.88 v1(90.7,110.09)
BOARD_ID8: length 11.4
  BOTTOM w0.102: 96.05,102.98 96.05,100.91 95.72,100.58 95.16,100.58 94.17,99.58 93.05,99.58 92.51,99.05 92.51,98.12 92.1,97.71 U21.B29
  BOTTOM w0.127: R492.1 96.95,105.31 96.95,104.93 96.5,104.47 R491.2 96.5,103.96 96.05,103.52 96.05,102.98
BT_EN: length 17.2
  TOP w0.14: U16.82 149.33,24.86 149.44,24.98 149.76,24.98 150.12,25.34 150.12,26.11 v1(150.44,26.43) 150.44,26.43 151.31,27.3 151.67,27.3 153.3,28.93 v1(154.32,28.93)
  BOTTOM w0.127: CN9.54 159.24,31 159.04,31.2 155.71,31.2 154.65,30.13 154.65,29.25 v1(154.32,28.93)
CCD+DMIC_PWR: length 1.9
  BOTTOM w0.254: CN3.32 61.77,125.95 ; CN3.33 61.51,126.45
  vias: v1(62.26,126.1)
CLK_LAN_REQ#: length 17.7
  TOP w0.127: Q15.6 31.88,26.23 31.61,26.5 31.61,27.88 32.84,29.11 35.6,29.11 v1(36.18,29.7) 36.18,31.73 36.18,31.73 R226.2 35.71,32.12 33.64,32.12 33.15,32.61 33.15,34.06 32.81,34.4 32.28,34.4 31.76,34.91 U13.29
CLK_PCI_EC: length 210.9
  TOP w0.127: U16.13 132.19,25.66 132.61,26.08 v1(132.61,26.33)
  IN1 w0.102: v1(44.15,31.72) 54.95,31.72 68.95,17.72 80.59,17.72 81.9,19.03 90.01,19.03 90.52,18.51 113.08,18.51 113.74,19.18 113.74,20.32 114.79,21.38 114.79,22.05 116.68,23.94 117.73,23.94 121.83,28.05 123.93,28.05 125.55,29.67 126.98,29.67 127.93,28.72 130.22,28.72 v1(132.61,26.33)
  IN3 w0.127: v1(44.15,31.72) 37.51,38.35 37.51,53.85 35.8,55.56 35.8,58.39 34.62,59.57 34.62,73.56 37.21,76.15 37.21,78.95 36.56,79.59 36.56,81.89 43.09,88.42 44.06,88.42 49.13,93.5 56.51,93.5 57.6,92.4 59.24,92.4 59.59,92.05 60.52,92.05 64.17,95.7 69.56,95.7 70.11,95.15 70.11,94.39 71.36,93.14 71.36,92.4 73.14,90.62 73.14,90.02 v1(72.58,89.46)
  BOTTOM w0.102: v1(72.58,89.46) 71.58,89.46 R379.2
  BOTTOM w0.127: v1(132.61,26.33) 132.31,26.63 131.3,26.63 130.83,26.16 R467.2
CLK_PCI_LPC: length 203.1
  IN3 w0.127: v1(59.78,88.89) 59.66,89 58.33,89 57.97,89.35 56.34,89.35 55.24,90.45 50.45,90.45 40.32,80.32 40.32,39.37 51.47,28.22 62.6,28.22 63.05,27.77 63.05,23.99 68.95,18.09 80.17,18.09 81.18,19.09 85.07,19.09 85.67,19.7 92.74,19.7 93.46,18.98 101.84,18.98 104.41,21.55 106.04,21.55 107.31,22.82 107.31,24.64 107.61,24.94 107.61,26.68 109.19,28.25 111.67,28.25 112.04,28.62 113.62,28.62 114.04,28.2 120.13,28.2 120.93,29 122.27,29 125.35,32.08 126.6,32.08 127.31,31.37 127.31,30.73 128.75,29.29 131.54,29.29 132.45,30.2 132.84,30.2 134.18,28.86 136.13,28.86 136.86,28.12 145.63,28.12 145.93,27.82 v1(151.48,27.82)
  BOTTOM w0.127: R380.2 60.44,88.73 60.28,88.89 v1(59.78,88.89) ; v1(151.48,27.82) 151.48,27.25 151.98,26.75 CN9.71
CLK_PCIE_LAN_REQ#: length 90.7
  TOP w0.127: v1(45.27,46.24) 45.27,41.99 44.63,41.35 44.63,35.27 40.72,31.37 39.8,31.37 36.94,28.52 36.94,26.88 36.16,26.09 35.43,26.09 35.29,26.23 Q15.1
  BOTTOM w0.102: U21.AH61 76.46,85.32 76.46,84.82 76.28,84.65 76.03,84.65 75.91,84.77 75.66,84.77 75.4,84.51 75.13,84.51 74.89,84.26 74.43,84.26
  BOTTOM w0.127: v1(45.27,46.24) 42.63,48.88 42.63,61.02 45.7,64.09 50.03,64.09 53.5,67.57 53.5,74.83 53.81,75.14 56.75,75.14 57.91,76.3 R485.2 R397.2 62.68,79.11 63.89,79.11 66.79,82.01 69.63,82.01 70.46,82.84 71.82,82.84 72.15,83.16 72.85,83.16 73.94,84.26 74.43,84.26
CLK_PCIE_LANN: length 178.5
  TOP w0.127: U13.24 30.38,31.87 31.07,31.18 31.07,28.91 30.95,28.79 30.95,28.32 v1(31.13,28.14)
  IN1 w0.102: v1(31.13,28.14) 30.93,28.34 30.93,28.49 31.03,28.59 32.85,28.59 39.37,35.1 103.57,35.1 104.45,34.22 107.97,34.22 108.85,35.1 113.16,35.1 114.49,36.44 115.58,36.44 116.76,37.62 116.76,38.7 123.64,45.58 123.64,49.3 124.68,50.33 124.68,66.41 122.69,68.4 122.69,81.01 114.26,89.44 114.26,90.96 111.92,93.3 111.92,96.04 110.4,97.57 109.97,97.57 v1(109.77,97.77)
  BOTTOM w0.102: U21.B8 101.56,97.53 101.56,98.83
  BOTTOM w0.127: 101.56,98.83 103.25,100.52 104.92,100.52 105.24,100.84 107.83,100.84 108.45,100.22 108.45,97.85 108.7,97.6 109.61,97.6 v1(109.77,97.77)
CLK_PCIE_LANP: length 178.4
  TOP w0.127: v1(30.31,28.14) 30.62,28.14 30.69,28.21 30.69,28.89 30.81,29.01 30.81,31.08 30.2,31.69 29.98,31.91 U13.23
  IN1 w0.102: v1(109.79,96.95) 109.79,97.31 109.85,97.36 110.31,97.36 111.72,95.96 111.72,93.22 114.06,90.88 114.06,89.36 122.48,80.93 122.48,68.31 124.47,66.32 124.47,50.42 123.43,49.38 123.43,45.66 116.56,38.79 116.56,37.71 115.49,36.64 114.41,36.64 113.08,35.3 108.77,35.3 107.89,34.42 104.53,34.42 103.65,35.3 39.29,35.3 32.77,28.79 30.95,28.79 30.73,28.57 30.73,28.2 30.67,28.14 v1(30.31,28.14)
  BOTTOM w0.102: 101.79,98.74 101.77,98.71 101.77,98.24 U21.A7
  BOTTOM w0.127: 101.79,98.74 103.34,100.29 105.02,100.29 105.34,100.61 107.74,100.61 108.22,100.13 108.22,97.76 108.6,97.37 109.63,97.37 109.79,97.21 v1(109.79,96.95)
CLK_PCIE_SSD_REQ#: length 90.5
  TOP w0.127: v1(24.9,94.98) 24.85,95.03 24.85,97.4 26.86,99.4 32.11,99.4 32.36,99.16 U4.3 32.36,96.97 31.4,96.01 Q36.6
  IN1 w0.102: v1(26.28,91.19) 26.28,89.87 23.04,86.64 23.04,83.96 25.59,81.41 43.67,81.41 46.16,78.92 49.77,78.92 v1(54.19,74.5)
  BOTTOM w0.102: 74.92,84 75.22,84.3 75.61,84.3 U21.AK62
  BOTTOM w0.127: v1(26.28,91.19) 26.28,93.43 24.9,94.8 v1(24.9,94.98) ; 74.92,84 74.51,84 73.34,82.83 72.17,82.83 71.53,82.19 70.47,82.19 69.64,81.36 67.06,81.36 62.65,76.95 61.48,76.95 R398.2 61.28,75.86 61.28,75.29 59.73,73.74 54.95,73.74 v1(54.19,74.5)
CLK_PCIE_SSDN: length 89.1
  IN1 w0.102: v1(28.42,98.62) 28.04,98.62 27.97,98.69 27.97,99.06 28.24,99.32 40.91,99.32 41.39,99.8 43.47,99.8 45.37,101.71 45.37,102.82 45.88,103.33 47.39,103.33 51.43,107.37 73.13,107.37 74.8,109.04 77.62,109.04 79.61,111.03 81.98,111.03 83.85,109.16 86.09,109.16 90.79,104.47 93.08,104.47 96.18,101.37 98.18,101.37 99.54,100.02 100.37,100.02 100.49,99.9 100.49,99.34 100.42,99.28 100.21,99.28 v1(100.08,99.41)
  BOTTOM w0.102: v1(100.08,99.41) 100.2,99.53 100.39,99.53 100.5,99.42 100.5,98.96 99.92,98.38 99.92,97.73 U21.B11
  BOTTOM w0.127: CN5.53 28.18,97.71 28.01,97.88 28.01,98.48 28.15,98.62 v1(28.42,98.62)
CLK_PCIE_SSDP: length 89.1
  IN1 w0.102: v1(27.57,98.62) 27.77,98.82 27.77,99.14 28.15,99.53 40.83,99.53 41.31,100.01 43.38,100.01 45.16,101.79 45.16,102.9 45.8,103.54 47.31,103.54 51.35,107.58 73.05,107.58 74.72,109.25 77.54,109.25 79.53,111.24 82.06,111.24 83.93,109.37 86.18,109.37 90.87,104.67 93.17,104.67 96.26,101.58 98.27,101.58 99.63,100.22 100.45,100.22 100.69,99.98 100.69,99.6 v1(100.9,99.39)
  BOTTOM w0.102: U21.C11 100.15,97.51 100.23,97.58 100.23,97.84 100.12,97.95 100.12,98.3 100.7,98.88 100.7,99.18 v1(100.9,99.39)
  BOTTOM w0.127: v1(27.57,98.62) 27.73,98.46 27.73,97.86 27.68,97.81 CN5.55
CLK_PCIE_WLANN: length 115.6
  IN3 w0.127: v1(106.89,100.15) 106.69,100.35 106.69,100.55 106.88,100.74 107.62,100.74 108.19,100.17 115.14,100.17 120.26,95.05 120.26,93.15 123.28,90.12 124.03,90.12 126.14,88.02 126.14,79.01 127.21,77.94 127.21,62.08 130.47,58.82 133.58,55.71 133.58,54.71 138.39,49.9 141.55,49.9 142.39,49.06 149.86,49.06 150.28,48.64 155.84,48.64 157.13,47.35 157.13,43.16 157.49,42.8 157.79,42.8 v1(158.05,42.54)
  BOTTOM w0.089: 102.44,98.35 102.44,98.33 102.42,98.32 102.42,97.98 102.5,97.9 102.5,97.6 102.58,97.52 U21.B5
  BOTTOM w0.102: v1(106.89,100.15) 106.71,100.15 106.63,100.07 106.63,99.57 106.36,99.3 105.42,99.3 105.06,99.66 103.48,99.66 102.44,98.61 102.44,98.35
  BOTTOM w0.127: CN9.49 153.95,32.25 154.06,32.36 154.85,32.36 156.2,33.71 156.2,36.09 157.21,37.11 157.21,42.41 157.53,42.73 157.86,42.73 v1(158.05,42.54)
CLK_PCIE_WLANP: length 115.7
  IN3 w0.127: v1(106.23,100.15) 106.44,100.35 106.44,100.66 106.77,100.99 107.73,100.99 108.3,100.42 115.25,100.42 120.51,95.16 120.51,93.25 123.38,90.38 124.14,90.38 126.4,88.12 126.4,79.11 127.46,78.05 127.46,62.19 133.84,55.81 133.84,54.81 138.5,50.15 141.65,50.15 142.49,49.31 149.96,49.31 150.39,48.89 155.95,48.89 157.38,47.46 157.38,43.27 157.6,43.05 157.91,43.05 v1(158.05,43.2)
  BOTTOM w0.089: U21.B7 102.33,97.68 102.33,97.83 102.25,97.91 102.25,98.32 102.23,98.33 102.23,98.35
  BOTTOM w0.102: v1(106.23,100.15) 106.43,99.96 106.43,99.65 106.27,99.5 105.5,99.5 105.14,99.86 103.4,99.86 102.23,98.69 102.23,98.35
  BOTTOM w0.127: v1(158.05,43.2) 157.84,42.98 157.42,42.98 156.96,42.52 156.96,37.22 155.94,36.2 155.94,33.82 154.74,32.62 154.06,32.62 153.93,32.75 CN9.47
CLK_SCLK: length 256.2
  TOP w0.127: v1(168.82,29.04) 168.82,25.87 163.38,20.43 163.38,17.61 161.44,15.67 ; R38.1 66.07,95.91 65.37,95.21 65.37,93.14 64.2,91.96 64.2,91.24 v1(63.39,90.44)
  TOP w0.305: 161.44,15.67 U17.4
  IN3 w0.127: v1(63.39,90.44) 63.84,89.98 63.84,88.77 63.55,88.48 60.43,88.48 60.26,88.3 59.32,88.3 59.14,88.48 58.11,88.48 57.76,88.83 56.12,88.83 55.03,89.93 50.65,89.93 40.83,80.11 40.83,39.6 51.7,28.73 63.28,28.73 63.61,28.4 63.61,24.26 66.43,21.44 83.88,21.44 85,20.31 92.86,20.31 93.69,19.49 101.61,19.49 104.19,22.07 105.82,22.07 106.79,23.04 106.79,24.86 107.09,25.16 107.09,26.89 108.97,28.77 111.45,28.77 111.83,29.15 113.83,29.15 114.27,28.7 119.72,28.7 121.1,30.09 122.63,30.09 125.14,32.59 126.81,32.59 127.82,31.58 127.82,30.94 128.97,29.8 130.55,29.8 131.47,30.72 133.05,30.72 134.41,29.36 136.36,29.36 137.09,28.63 148.18,28.63 148.48,28.33 151.91,28.33 153.57,29.99 154.51,29.99 154.94,30.42 156.12,30.42 156.5,30.8 160.78,30.8 162.27,29.3 167.99,29.3 168.26,29.04 v1(168.82,29.04)
  BOTTOM w0.127: Q29.1 65.88,95.68 65.38,95.18 64.6,95.18 62.67,93.25 62.67,91.34 63.39,90.62 v1(63.39,90.44)
CLK_SDATA: length 248.7
  TOP w0.127: R45.1 67.2,93.97 66.79,93.55 v1(66.79,93.19) ; v1(168.3,29.77) 168.3,26.06 162.88,20.65 162.88,19.39 162.33,18.84 161.79,18.84 v1(161.48,19.16) 160.89,19.75 157.44,19.75
  TOP w0.305: 157.44,19.75 157.18,19.49 U17.6
  IN3 w0.127: v1(168.3,29.77) 168.26,29.81 162.5,29.81 161,31.31 155.82,31.31 155.66,31.15 154.01,31.15 152.08,29.22 150.65,29.22 150.19,29.68 144.18,29.68 144.06,29.56 137.39,29.56 136.7,30.26 134.25,30.26 133.27,31.24 131.27,31.24 130.33,30.31 129.19,30.31 128.33,31.17 128.33,31.79 127.02,33.1 124.92,33.1 122.42,30.6 120.89,30.6 120.07,29.78 114.33,29.78 113.93,30.17 112.17,30.17 111.89,29.89 109.86,29.89 109.4,29.42 108.29,29.42 107.59,28.73 107.59,28.21 106.52,27.14 106.14,27.14 105.7,26.7 105.7,23.81 104.47,22.58 103.97,22.58 101.38,19.99 93.92,19.99 93.08,20.83 85.2,20.83 84.09,21.95 66.66,21.95 64.12,24.49 64.12,28.91 63.79,29.24 51.93,29.24 41.34,39.82 41.34,79.84 50.91,89.41 52.3,89.41 52.7,89.01 55.21,89.01 55.91,88.31 57.54,88.31 57.89,87.96 58.93,87.96 59.1,87.78 60.47,87.78 60.65,87.96 63.75,87.96 64.36,88.57 64.36,92.23 64.96,92.83 66.43,92.83 v1(66.79,93.19)
  BOTTOM w0.127: Q29.4 67.18,93.9 66.79,93.5 v1(66.79,93.19)
CLKDRV_RCOMP: length 2.2
  TOP w0.127: R42.2 95.32,95.84 v1(94.84,95.84)
  BOTTOM w0.254: v1(94.84,95.84) 95.21,96.21 U21.E21
CLKREQ_SSD#: length 12.9
  TOP w0.127: v1(28.56,94.98) 28.56,95.2 v1(28.96,95.6) 29.2,95.85 R484.2 30.47,96.47 30.75,96.19 Q36.5 30.75,94.9 31.2,94.44 31.99,94.44 32.36,94.81 U4.4
  BOTTOM w0.102: 28.43,89.54 CN5.52
  BOTTOM w0.127: 28.43,89.54 28.43,94.84 v1(28.56,94.98)
CLKREQ_WLAN#: length 39.5
  TOP w0.127: Q35.5 168.01,32.34 167.75,32.09 167.75,31.54 167.97,31.32 168.64,31.32 169.03,30.93 R483.2 169.56,30.56 170.48,31.49 170.48,33.42 170.19,33.71 v1(169.68,33.71) 169.42,33.98 U29.4
  IN1 w0.102: v1(151.3,38.36) 153.25,40.31 163.08,40.31 v1(169.68,33.71)
  BOTTOM w0.127: CN9.53 152.38,31.25 152.13,31.51 152.13,32.35 152.13,32.35 151.3,33.18 v1(151.3,37.33) v1(151.3,38.36)
CLKRUN#: length 232
  TOP w0.127: U14.13 158.22,31.15 v1(157.58,30.5) 157.7,30.38 C233.2 156.81,29.68 156.54,29.42 156.54,27.79 155.6,26.84 v1(155.6,26.71) ; U16.93 146.38,29.26 146.21,29.09 146.21,27.42 145.65,26.86 v1(145.65,24.99)
  IN3 w0.127: v1(70.6,92.77) 70.6,92.96 69.15,94.4 64.71,94.4 61.02,90.72 59.04,90.72 58.68,91.07 57.05,91.07 55.95,92.16 49.7,92.16 44.64,87.1 43.6,87.1 37.9,81.4 37.9,80.08 38.5,79.48 38.5,71.94 37.28,70.72 37.28,59.91 38.48,58.71 38.48,38.79 50.8,26.47 54.49,26.47 55.7,25.26 59.44,25.26 68.33,16.37 83.08,16.37 84.03,17.33 116.05,17.33 117.69,18.97 117.69,22.21 122.09,26.61 122.41,26.61 122.67,26.87 128.94,26.87 129.38,26.43 131.01,26.43 131.46,26.88 134.08,26.88 135.45,25.5 140.88,25.5 141.87,24.52 145.17,24.52 v1(145.65,24.99) 145.85,24.8 153.84,24.8 155.59,26.54 155.59,26.7 v1(155.6,26.71)
  BOTTOM w0.102: v1(70.6,92.77) 70.95,92.41 R371.2
CLKRUN#_R: length 4.8
  BOTTOM w0.089: U21.V62 74.79,90.05 74.41,90.42
  BOTTOM w0.114: 74.41,90.42 72.43,92.41 R371.1
CLR_CMOS: length 177.8
  TOP w0.14: v1(147.58,41.97) 147.58,40.83 148.27,40.14 148.27,33.25 152.1,29.41 154.48,29.41 154.77,29.12 154.77,28.72 154.53,28.48 153.23,28.48 152.72,27.97 152.72,24.67 v1(152.16,24.11) 152.16,24.01 151.26,23.11 150.16,23.11 R254.1 149.26,23.56 148.95,23.86 148.08,23.86 147.88,23.66 U16.79 ; Q11.2 Q11.5 51.65,69.96 44.59,62.9 44.59,55.7 42.47,53.58 42.47,50.06 44.63,47.9 44.63,42.26 43.84,41.47 v1(43.84,40.93)
  IN2 w0.127: v1(147.58,41.97) 147.22,41.61 145.47,41.61 145.37,41.71 138.23,41.71 137.62,42.32 128.95,42.32 128.44,42.84 121.36,42.84 116.01,37.49 114.11,37.49 113.59,36.98 109.69,36.98 108.01,35.3 102.02,35.3 100.88,34.17 49.25,34.17 43.84,39.58 v1(43.84,40.93)
CODEC_VREF: length 2.7
  TOP w0.203: C249.2 207.04,25.41 206.39,25.41 v1(206.31,25.33) 206.28,25.33 206.21,25.41 205.76,25.41 205.56,25.6 U15.28
D/C#: length 88.8
  TOP w0.14: U16.3 132.54,29.66 v1(132.58,29.71)
  IN3 w0.127: v1(132.58,29.71) 132.14,29.26 132.14,28.84 132.45,28.53 135.03,28.53 135.76,27.79 145.47,27.79 145.8,27.47 149.36,27.47 149.44,27.38 151.77,27.38 153.84,29.45 154.68,29.45 155.15,29.91 160.93,29.91 162.04,28.8 167.78,28.8 168.86,27.72 171.38,27.72 177.59,21.5 180.73,21.5 181.52,20.71 184.03,20.71 v1(184.44,21.11)
  BOTTOM w0.14: v1(184.44,21.11) 184.54,21.21 184.54,21.9 183.54,22.91 183.54,25.01 187.31,28.78 189.7,28.78 191.74,30.82 195.28,30.82 196,30.09 196.92,30.09 197.76,30.93 197.76,33.15 198.61,34.01 201.05,34.01 201.78,34.74 PR189.2
DDCCLK_NOR: length 2.9
  TOP w0.14: R104.1 R103.2 27.15,74.64 27.38,74.41 27.38,74.21 27.25,74.08 Q10.4
DDCCLK_NOR-1: length 10.9
  TOP w0.127: Q10.3 29.03,74.08 29.49,74.54 v1(29.62,74.54) ; R108.2 v1(21.59,72.48)
  BOTTOM w0.127: v1(21.59,72.48) 23.65,74.54 v1(29.62,74.54)
DDCCLK_RIN: length 2.3
  TOP w0.127: R120.1 27.69,69.43 27.69,69.1 28.45,68.34 U6.7
DDCCLK_ROUT: length 18.6
  TOP w0.127: v1(20.2,72.52) 20.16,72.48 R107.2
  TOP w0.14: v1(28.77,61.78) 28.95,61.96 U6.19
  IN1 w0.102: v1(28.77,61.78) 28.21,61.21 26.76,61.21 25.44,62.53 25.44,65.48 23.38,67.54 22.82,67.54 19.8,70.56 19.8,72.12 v1(20.2,72.52)
DDCDATA_NOR: length 2.7
  TOP w0.102: Q10.1 28.1,72.78 27.46,72.15 R112.2
  TOP w0.127: R113.1 27.97,71.71 27.87,71.81 R112.2
DDCDATA_NOR-1: length 10.9
  TOP w0.127: R115.2 20.83,70.96 21.2,71.33 21.63,71.33 21.77,71.48 21.77,71.94 21.92,72.09 22.13,72.09 22.28,71.94 22.28,71.48 22.43,71.33 22.77,71.33 22.89,71.2 22.89,70.87 23.04,70.72 23.25,70.72 23.4,70.87 23.4,71.46 23.52,71.58 24.5,71.58 24.64,71.73 24.64,72.45 v1(24.77,72.58) 24.77,72.87 24.93,73.03 25.1,73.03 25.25,72.89 25.25,72.27 25.4,72.12 25.61,72.12 25.76,72.27 25.76,72.63 25.91,72.78 Q10.6
DDCDATA_RIN: length 2.3
  TOP w0.127: R121.1 28.17,69.41 28.17,69.1 28.95,68.32 U6.6
DDCDATA_ROUT: length 17.1
  TOP w0.127: v1(20.34,71.23) 20.11,71.23 R114.2
  TOP w0.14: v1(29.45,61.84) 29.45,61.84 U6.20
  IN1 w0.102: v1(29.45,61.84) 28.98,62.31 28.56,62.31 27.95,61.7 26.96,61.7 25.93,62.73 25.93,65.68 20.62,70.99 20.59,70.99 v1(20.34,71.23)
DDI0_RCOMP_N: length 5.6
  BOTTOM w0.102: U21.AG2 104.4,86.04 104.73,86.04 104.84,86.15 105.25,86.15 106.17,87.08 108.54,87.08 108.8,86.82
  BOTTOM w0.14: R385.1 109.01,86.61 108.8,86.82
DDI0_RCOMP_P: length 3.8
  BOTTOM w0.102: R385.2 108.06,86.88 106.26,86.88 105.25,85.87 U21.AG1
DE1: length 4.2
  TOP w0.14: R220.1 207.25,34.41 v1(206.71,34.95) 206.37,34.95 205.97,35.34 U12.9
  BOTTOM w0.127: R452.2 207.28,34.38 v1(206.71,34.95) v1(206.71,35.59)
DE2: length 9
  TOP w0.14: U12.8 205.5,35.87 205.5,35.04 v1(205.55,34.99) 206.16,34.38 R219.1
  BOTTOM w0.127: 206.69,36.33 208.12,34.9 R453.2
  BOTTOM w0.14: v1(205.55,34.99) v1(205.55,36.15) 205.73,36.33 206.69,36.33
DEW1: length 3.2
  TOP w0.127: U12.16 206.68,39.7 v1(207.02,39.36)
  BOTTOM w0.127: v1(207.02,39.36) 207.02,38.92 207.41,38.53 R444.1 207.86,37.97 R447.2
DEW2: length 3.9
  TOP w0.127: R218.2 202.81,35.44 v1(202.96,35.59)
  TOP w0.14: R217.1 R218.2 ; v1(202.96,35.59) 204.02,35.59 204.16,35.46 204.37,35.46 204.47,35.56 U12.6
DMIC_CLK: length 195.5
  TOP w0.127: R243.1 v1(194.7,27.61) 193.7,27.61 C241.1 193.42,27.81 191.87,29.36 177.7,29.36 168.16,38.9 158.87,38.9 157.59,40.19 156.69,40.19 150.2,46.68 137.84,46.68 137.45,46.29 v1(130.21,46.29)
  IN1 w0.102: v1(130.21,46.29) 129.69,46.81 129.69,48.11 126.12,51.67 126.12,67.01 124.13,69 124.13,81.58 119.24,86.47 119.24,91.76 117.32,93.68 117.32,95.01 110.13,102.21 106.88,102.21 105.59,103.5 105.59,105.17 104.86,105.9 104.86,109.25 102.69,111.42 88.43,111.42 87.59,112.26 85.11,112.26 83.26,114.12 78.32,114.12 76.3,112.11 73.55,112.11 72.37,110.92 67.43,110.92 67.16,111.2 v1(64.95,111.2)
  BOTTOM w0.127: R280.1 64.32,110.43 D14.2 65.14,110.7 65.14,111.01 v1(64.95,111.2)
