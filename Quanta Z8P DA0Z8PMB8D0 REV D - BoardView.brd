# Allegro board Quanta Z8P DA0Z8PMB8D0 REV D - BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+3VPCU_ECPLL: length 4.7
  TOP w0.203: 133.48,33.16 U16.127
  TOP w0.305: L4.1 133.55,35.56 133.55,34.65 133.14,34.24 C208.1 133.01,33.63 133.48,33.16
+3VPCU_SRC:
  vias: v1(130.14,116.21)
+5V: length 80.7
  TOP w0.508: 25.8,76.12 26.09,76.41 31.12,76.41 37.48,82.76 37.48,89.96 42.71,95.19 42.71,99.5 40.75,101.45 40.75,104.73 40.96,104.93 v1(41.01,104.93)
  IN1 w0.508: v1(41.01,104.93) 41.58,104.93 47.73,111.08 49.26,111.08 50.59,112.4 50.59,121.8 55.23,126.45 60.31,126.45 62.32,124.44 v1(66.11,124.44)
  BOTTOM w0.508: R277.1 v1(66.11,124.44)
  vias: v1(145.11,29.24) v1(145.77,29.24) v1(197.51,23.62) v1(197.5,22.99) v1(212.36,30.92) v1(212.99,30.54) v1(213.7,30.69) v2(25.51,76.61) v2(25.51,75.85) v2(142.76,42.9) v2(143.52,42.9) v2(144.28,42.9) v2(146.11,50.58) v2(146.54,52.1) v2(146.54,51.34) v2(146.87,50.58) v2(229.11,20.71) v2(229.49,20.07) v2(229.83,20.86) v2(230.21,20.23)
+5V_FAN1:
  vias: v1(215.25,30.69) v2(216.01,31.07) v2(216.75,31.07)
+5V_KB:
  vias: v1(228.81,15.88) v1(228.87,14.99) v1(229.55,14.97)
+5V_ODD: length 50.7
  IN2 w0.508: v1(142.85,26.63) 142.28,27.19 141.75,27.73 132.13,27.73 130.94,28.91 127.69,28.91 126.73,29.88 125.28,29.88 124.1,28.69 121.24,28.69 120.32,27.78 120.32,27.33 117.69,24.69 116.62,24.69 115.48,23.55 113.42,23.55 113.29,23.42 110.04,23.42 109.63,23.83 109.63,29.22 108.6,30.24 v1(108.6,31.82)
  BOTTOM w0.381: 112.17,32.95 111.7,33.43 110.99,33.43 110.59,33.03 R456.2 110.29,32.54 109.91,32.54 109.3,31.93 C405.2 v1(108.6,31.82)
  vias: v1(138.5,21.14) v1(139.13,21.14) v1(139.79,21.14) v2(142.78,23.62) v2(143.54,23.62) v2(144.31,23.62)
+5V_PVDD: length 3.6
  TOP w0.203: U15.46 200.49,30.31 200.13,30.67 199.09,30.67 198.84,30.92 ; U15.41 202.49,30.7 v1(202.4,30.79)
  vias: v1(198.56,31.78) v1(199.07,32.19) v1(200.11,32.39)
+5V_S5: length 247.2
  TOP w0.508: ESD1.5 17.59,85.12 17.95,84.76 v1(17.95,84.65) ; R96.1 31.39,79.63 31.33,79.68 31.33,81.64 33.74,84.05 33.74,88.23 ; v1(122.3,123.76) 120.82,125.24 120.82,126.84 119.54,128.12 119.54,131.53 118.65,132.42 117.45,132.42 116.19,133.67 114.24,133.67 112,135.91 103.42,135.91 101.71,137.62 PR1.1 100.73,138.49 99.71,139.51 86.59,139.51 84.09,137.01 PR2.1 ; PR64.2 PR65.2 106.09,23.69 v1(106.33,23.94)
  IN1 w0.508: v1(17.95,84.65) 17.95,85.26 20.36,87.66 21.53,87.66 25.89,92.03 30.9,92.03 32.27,90.66 v2(32.44,90.66) ; v1(106.33,23.94) 106.99,23.94 107.49,24.44 107.49,26.98 109.32,28.81 112.71,28.81 113.72,29.82 114.92,29.82 115.51,30.42 115.51,31.1 116.35,31.94 118.76,31.94 119.65,32.84 123.27,32.84 126.86,36.42 126.86,38.01 132.55,43.71 v1(132.55,43.72) ; v1(122.3,123.76) 121.59,124.47 117.13,124.47 116.5,123.84 116.5,121.57 v1(114.64,119.72) 111.07,116.14 109.23,116.14 108.72,115.63 108.72,108.46 107.51,107.25 107.51,104.21 108.18,103.55 110.62,103.55 118.64,95.53 118.64,94.22 122.26,90.61 122.26,86.48 125.45,83.28 125.45,69.61 128.79,66.27 128.79,53.29 v1(130.84,51.24)
  IN3 w1.016: 39.91,100.07 39.91,101.31 42.66,104.06 42.66,109.85 44.36,111.56 50.34,111.56 52.03,109.87 57.07,109.87 58.03,110.83
  BOTTOM w0.508: v1(189.69,26.37) 189.69,26.03 189.28,25.62 R468.1 189.28,24.83 189.39,24.72 R474.1 ; v1(122.3,123.76) 121.97,124.09 PR117.1 ; v1(114.64,119.72) 114.41,119.46 PR132.2
  vias: v1(224.23,14.36) v1(224.99,14.25) v1(225.65,14.25) v1(226.07,15.91) v1(226.31,14.25) v1(226.81,15.88) v1(226.83,15.22) v2(25.14,57.61) v2(25.2,58.44) v2(25.95,58.53) v2(26.48,58) v2(33.21,90.66) v2(33.97,90.66) v2(34.73,90.66) v2(39.06,98.77) v2(40.01,98.74) v2(47.4,39.4) v2(47.88,38.82) v2(58.52,111.94) v2(59.28,111.94) v2(125.82,47.63) v2(125.82,46.87) v2(126.58,47.63) v2(126.58,46.87) v2(127.23,48.46) v2(127.34,47.63) v2(127.34,46.87) v2(128.1,47.63) v2(128.1,46.87) v2(141.22,50.96) v2(141.59,51.61) v2(141.91,50.64) v2(142.63,49.88) v2(142.67,50.64) v2(143.42,50.64) v2(143.38,49.82) v2(143.87,51.65) v2(144.1,50.02) v2(144.16,50.77)
+5VA: length 13.3
  TOP w0.203: v1(205.96,24.42) 205.58,24.8 U15.26
  TOP w0.508: v1(205.96,24.42) 205.96,24.1 v1(206.34,23.73) 206.61,23.45 C259.1
  BOTTOM w0.508: v1(205.96,24.42) 205.96,24.1 206.44,23.63 C428.1 206.69,22.95 205.58,22.95 205.08,22.46 204.05,22.46 203.47,23.04 202.8,23.04 202.39,23.45 L11.2
+5VPCU: length 94.8
  IN3 w0.508: v1(124.34,114.43) 127.58,114.43 129.91,112.1 131.39,112.1 132.04,111.45 132.04,94.44 135.27,91.2 142.68,91.2 149.42,84.45 149.42,62.44 148.81,61.83 v2(147.58,61.83)
  BOTTOM w0.508: PR137.2 v1(124.34,114.43) ; v2(141.45,62.43) 139.89,63.99 135.61,63.99 133,61.38 133,57.67 134.9,55.77 134.9,54.96 138.31,51.54 PR179.2
  vias: v1(141.64,57.64) v1(145.4,62.97) v1(146.98,65.23) v1(149.06,57.46) v2(141.29,65.22) v2(141.29,64.34) v2(141.45,61.66) v2(142.21,62.43) v2(142.21,61.66) v2(142.97,62.43) v2(142.97,61.66) v2(146.21,65.1) v2(146.21,64.25) v2(147.58,63.35) v2(147.58,62.59)
+5VPCU_SRC:
  vias: v1(139.69,66.53)
+12V_PANEL: length 29.4
  TOP w0.254: PR9.2 v1(54.7,130.84) ; PR210.1 v1(62.46,133.57)
  IN1 w0.254: v1(54.7,130.84) 52.84,128.97 51.63,128.97 50.11,127.44 50.11,117.89 49.93,117.72 v1(49.93,114.93)
  IN3 w0.254: v1(54.7,130.84) 55.38,130.84 55.82,131.27 57.39,131.27 58.41,132.29 61.2,132.29 62.46,133.55 v1(62.46,133.57)
  vias: v1(49.93,114.26) v1(49.93,113.55) v1(49.95,112.89) v1(50.2,110.72)
+A3VPCU: length 31.5
  TOP w0.203: 149.33,21.44 148.94,21.83 148.1,21.83 147.94,21.66 U16.74
  TOP w0.305: 149.33,21.44 149.6,21.17 150.09,21.17 150.33,20.93 C267.1 150.73,20.15 150.64,20.06 150.64,19.77 150.2,19.33 150.2,18.88 149.84,18.52 148.78,18.52 148.42,18.87 v1(148.42,18.98)
  IN3 w0.305: v1(148.42,18.98) 148.14,18.98 146.5,20.62 143.89,20.62 143.46,20.19 133.6,20.19 132.64,21.15 131.44,21.15 131.13,20.83 v1(131.13,17.43)
  BOTTOM w0.305: v1(131.13,17.43) 130.92,17.61 L12.2
+VCC_1.05V_INT: length 2
  BOTTOM w0.305: v1(98.41,91.8) 98.22,91.61 U21.T15 ; U21.P16 97.83,91.97 v1(98.28,92.43) ; U21.T13 99.19,91.33 v1(99.19,91.51)
  vias: v2(116.89,88.96) v2(117.45,88.4) v2(118.01,87.84) v2(118.56,87.28)
+VCC_1.05V_IO:
  vias: v1(93.73,90.06) v1(93.73,89.33) v1(93.74,88.6) v1(93.74,87.88) v1(94.54,87.9) v1(95.32,90.05) v1(96.09,90.05) v1(96.09,89.33) v1(118.02,92.07) v1(118.02,91.31) v1(118.63,91.67) v1(118.63,91.02) v1(118.64,90.36) v1(119.42,92.11)
+VCC_1.8V:
  vias: v1(67.14,84.36) v1(67.7,84) v1(84.29,87.87) v1(85.08,87.87) v1(92.97,85.72)
+VCC_1.24V_AUD_ISH_PLL:
  vias: v1(95.3,84.99) v1(111.64,84.7) v1(112.3,84.7)
+VCC_1.24V_DSI_CSI:
  vias: v1(96.11,87.89) v1(96.91,87.91) v1(124.8,87.65) v1(125.45,87.65) v1(125.54,88.3)
+VCC_1.24V_GLM: length 5.4
  TOP w0.508: C86.1 v1(92.16,84.28)
  IN3 w0.508: v1(92.16,84.28) 92.13,84.25 v1(88.23,84.25)
  BOTTOM w0.305: v1(88.23,84.25) 88.18,84.25 U21.AM37
  vias: v1(95.32,84.27) v1(96.1,84.27) v1(112.37,82.76) v1(112.76,82.17)
+VCC_1.24V_MPHY:
  vias: v1(95.33,87.88) v1(123.42,87.8) v1(123.63,88.42) v1(124.07,87.8)
+VCC_1.24V_USB2: length 2.4
  BOTTOM w0.508: v1(113.69,85.5) 114.94,85.5 115.58,84.86 R395.2
  vias: v1(95.32,85.69) v1(96.11,85.69)
+VCC_3.3V: length 1.8
  TOP w0.508: C77.1 92.86,84.87 v1(92.96,84.97)
  BOTTOM w0.305: U21.AK25 93.3,84.63 v1(92.96,84.97) 93.34,85.35 U21.AJ25
  vias: v1(64.55,84.62) v1(65.31,84.62) v1(85.07,89.33) v1(85.1,88.61)
+VCC_VCCGI: length 19.7
  TOP w0.381: C14.1 84.54,95.88 v1(84.56,95.85) 84.56,95.03 C16.1 ; C12.1 81.94,95.96 v1(82.12,95.78) ; v1(88.35,96.47) 88.47,96.59 C11.1
  TOP w0.508: PR30.1 103.58,121.98 102.22,121.98 PC20.1 ; C15.1 90.71,96.16 v1(91.13,95.74) 91.36,95.97 C13.1
  BOTTOM w0.254: U21.E37 88.05,96.21 88.32,96.47 v1(88.35,96.47) 88.54,96.47 U21.E35 ; PL4.2 94.6,122.36 95.14,122.9 98.16,122.9 98.47,122.59 PR126.2
  BOTTOM w0.305: U21.E43 84.7,95.85 v1(84.56,95.85) 84.4,95.85 84.1,96.15 U21.E45 ; U21.E50 81.69,96.21 v1(82.12,95.78) 82.22,95.78 82.57,96.13 U21.E48
  vias: v1(83.65,91.55) v1(84.55,91.59) v1(87.44,88.61) v1(87.44,87.89) v1(87.45,89.34) v1(88.23,90.05) v1(88.22,89.33) v1(88.23,88.61) v1(88.22,87.89) v1(88.23,87.16) v1(88.23,86.46) v1(89.8,87.18) v1(89.81,85.71) v1(89.81,84.99) v1(90.61,90.06) v1(90.61,89.33) v1(90.61,88.61) v1(90.61,87.88) v1(90.61,87.16) v1(90.61,86.43) v1(90.61,85.71) v1(90.61,84.99) v1(91.37,90.06) v1(91.37,89.34) v1(91.36,88.61) v1(91.36,87.89) v1(91.36,87.16) v1(91.36,86.44) v1(91.36,85.71) v2(90.38,116.87) v2(90.38,116.01) v2(90.36,115.04) v2(90.64,120.88) v2(90.66,122.13) v2(90.66,119.79) v2(91.68,116.85) v2(91.73,115.98) v2(91.73,115.09) v2(91.93,122.08) v2(92.06,120.83) v2(92.09,119.84) v2(93.22,116.78) v2(93.25,115.94) v2(93.27,115.12) v2(94.75,116.7) v2(94.77,115.86) v2(94.8,115.05) v2(96.37,116.78) v2(96.4,115.94) v2(96.42,115.12) v2(97.88,119.61) v2(98.11,121.09) v2(98.2,116.72) v2(98.23,115.89) v2(98.25,115.07) v2(98.84,120.17) v2(100.08,116.72) v2(100.11,115.89) v2(100.13,115.07) v2(102.3,116.34) v2(102.3,115.12) v2(102.37,118.09) v2(105.17,118.24) v2(105.24,116.82) v2(105.27,115.19)
+VDDI_EMMC: length 2.3
  TOP w0.079: 61.09,94.74 60.64,94.74 U2.K2
  TOP w0.127: v1(61.64,94.95) 61.42,94.74 61.09,94.74
  BOTTOM w0.508: C330.1 v1(61.64,94.95)
+VDDQ: length 2.2
  TOP w0.508: PR48.1 PC39.1 v1(104.76,32.85)
+VDDQ_VTT:
  vias: v1(62.27,37.39) v1(64.81,37.39) v1(67.35,37.39) v1(69.89,37.39) v1(72.43,37.39) v1(74.08,38.03) v1(94.25,38.21) v1(96.43,37.39) v1(99.4,37.39) v1(100.06,37.39) v1(100.85,37.39) v1(101.51,37.39)
+VIN: length 35.1
  TOP w0.14: PR45.2 219.46,32.11 219.46,34.16 219.33,34.3 PR44.2
  TOP w0.508: PR36.1 PR35.1 v1(139.4,90.04) ; PR49.1 73.26,30.55 v2(73.92,29.89) ; v2(69.05,129.73) 68.06,130.72 68.06,133.21 PR209.1
  IN1 w0.508: v2(135.57,84.56) 139.4,88.39 v1(139.4,90.04)
  IN3 w0.508: v1(139.4,90.04) 141.76,90.04 145.12,86.67 v1(145.12,86.35)
  BOTTOM w0.508: PR93.1 v1(132.42,135.32) ; v2(121.14,130.26) 120.48,129.6 120.48,128 122,126.48 PR114.2 ; PR158.1 v1(145.12,86.35)
  vias: v1(52.63,115.78) v1(53.34,115.79) v1(54,115.78) v1(217.23,35.44) v2(53.21,24.86) v2(53.23,24.02) v2(53.67,23.3) v2(69.06,128.84) v2(73.41,128.24) v2(73.91,29.1) v2(73.95,28.31) v2(73.93,27.54) v2(73.93,26.71) v2(74.7,29.9) v2(74.73,29.11) v2(74.7,28.3) v2(74.71,27.53) v2(74.7,26.69) v2(85.17,126.02) v2(85.44,126.79) v2(85.69,125.4) v2(86.02,126.17) v2(91.17,29.48) v2(91.93,29.48) v2(92.69,29.48) v2(107.29,131.29) v2(107.27,130.32) v2(108.15,131.29) v2(108.15,130.32) v2(109.05,131.29) v2(109.05,130.32) v2(121.14,134.32) v2(121.14,133.3) v2(121.14,132.29) v2(121.14,131.27) v2(134.76,83.06) v2(134.76,82.25) v2(134.76,81.46) v2(134.91,83.83) v2(135.57,83.04) v2(135.57,82.25) v2(135.57,81.47) v2(135.67,83.83) v2(216.9,39.2) v2(216.9,38.44) v2(216.91,37.63) v2(216.91,36.89) v2(217.54,39.58) v2(217.54,38.82) v2(217.49,36.39) v2(217.58,37.98) v2(217.6,37.17) v2(218.28,36.37) v2(218.39,37.18)
GND: length 993.7
  TOP w0.079: U2.Y2 60.64,100.23 61.15,100.23
  TOP w0.127: 61.47,99.91 61.15,100.23
  TOP w0.14: v1(61.63,99.75) 61.47,99.91
  TOP w0.203: U13.34 29.58,36.91 v1(28.18,35.51) ; U2.AA4 59.39,100.57 58.75,101.22 v1(58.75,101.23) ; v1(130.01,30.78) 130.33,30.46 U16.1 ; v1(142.75,30.61) 142.68,30.68 U16.104 ; v1(200.16,27.74) 200.02,27.6 U15.4 ; v1(148.87,28.78) 148.55,28.46 U16.91 ; ESD2.3 10.38,87.58 v1(10.36,87.61) ; v1(58.9,95.5) 59.39,95 U2.K4 ; U2.Y5 U2.AA6 ; U16.49 139.48,14.41
  TOP w0.254: U4.2 33.01,98.51 33.12,98.62 v1(33.56,98.62) ; v1(29.32,94.98) 29.83,95.48 Q36.4 ; Q20.4 v1(108.05,20.27) ; CN1.A1 6,88.55 CN1.B12 ; v1(31.68,98.62) 31.4,98.34 Q36.1 ; U14.9 156.22,31.14 156.06,30.97 155.82,30.97 155.65,31.14 v1(155.65,31.75) ; v1(68.59,91) 68.78,90.81 69.89,90.81 70.55,90.14 v1(70.55,90.05) 70.55,89.16 69.95,88.57 68.76,88.57 v1(68.57,88.75) ; U2.R10 57.03,97.49 v1(57.21,97.67) ; U2.P5 59.07,96.99 v1(59.33,97.24) ; PC51.1 48.63,22.38 v1(49.3,23.06) ; v1(57.17,99.05) 57.39,98.83 U2.U8 ; U2.AA6 58.39,100.75 57.91,101.24 v1(57.77,101.24) ; U29.2 v1(165.57,34.63) 165.57,33.55 166.13,32.99 Q35.1 ; U2.M7 57.89,95.92 57.59,95.61 v1(57.59,95.43) ; v1(92.1,98.64) 92.56,98.19 Q4.4 ; C276.1 148.73,14.45 ; U3.12 25.29,89.86 v1(25.29,89.86) ; Q35.4 169.66,31.69 v1(169.79,31.56) ; C34.1 67.78,91.2 67.78,91.85 67.5,92.13 65.59,92.13 65.19,91.73 65.19,88.37 65.64,87.91 67.47,87.91 67.93,88.37 C47.1
  TOP w0.279: v1(46.57,108.31) 46.57,108.08 46.79,107.87 46.79,107.52 46.55,107.28 Q3.1 ; v1(27.41,62.68) 27.41,62.33 27.51,62.24 27.88,62.24 27.95,62.31 U6.17 ; Q4.1 96.09,96.89 R40.2 ; U12.13 v1(208.29,37.8) ; U12.18 U12.21 ; U12.3 v1(202.64,37.8)
  TOP w0.305: U8.E7 58.89,55.55 58.89,56.25 v1(58.95,56.3) ; U11.D1 107.61,55.88 107.23,55.5 ; U10.B9 96.55,57.88 ; 96.55,57.88 U10.A9 ; 96.55,57.88 v1(96.56,57.88) ; U10.G9 v1(95.75,53.88) U10.G8 ; v1(114.59,49.48) U11.M9 ; U9.T1 v1(71.94,46.28) ; U8.G1 54.54,53.48 54.15,53.08 v1(54.15,53.07) ; v1(55.77,57.08) 56.17,57.48 U8.B3 ; U9.M1 72.45,49.51 v1(71.91,49.51) ; C87.1 81.1,82.23 v1(81.1,82.05) ; U10.G1 89.72,53.48 89.32,53.08 v1(89.32,53.07) ; v1(96.56,54.65) 96.55,54.65 96.18,54.28 U10.F9 ; U8.A9 61.37,57.88 ; 61.37,57.88 U8.B9 ; 61.37,57.88 v1(61.38,57.88) ; v1(79.41,47.72) 79.03,47.72 U9.P9 ; v1(96.23,45.73) 96.23,46.19 U10.T9 ; v1(107.03,47.88) U11.P1 ; U8.D3 56.17,55.88 v1(55.77,55.48) U8.E2 ; U8.G9 v1(60.57,53.88) U8.G8 ; U17.7 v1(156.68,19.64) ; U14.23 161.62,35.62 v1(161.87,35.87) ; U9.E1 72.05,55.5 ; 72.05,55.5 72.43,55.88 U9.D1 ; 72.05,55.5 v1(72.05,55.48) ; U9.B9 78.88,57.49 v1(79.29,57.9) 78.92,58.28 U9.A9 ; U11.D3 109.26,55.88 v1(108.86,55.48) U11.E2 ; v1(89.22,46.28) U10.T1 ; v1(78.49,51.44) 78.08,51.85 U9.J8 ; U8.F9 61,54.28 61.37,54.65 v1(61.38,54.65) ; U8.J8 60.52,51.52 v1(60.57,51.52) ; v1(72.05,57.9) U9.B1 ; v1(48.21,105.26) 48.4,105.26 48.65,105.52 48.65,105.8 48.46,105.98 Q3.4 ; v1(33.22,45.26) 32.6,45.88 31.36,45.88 C169.1 ; U9.M9 v1(79.41,49.48) ; v1(112.03,55.47) 112.42,55.08 U11.E7 ; v1(151.93,15.58) 152.84,14.67 U17.12 ; U14.16 159.72,31.43 159.87,31.28 v1(161.87,31.28) ; U10.D8 95.35,55.88 v1(95.77,55.45) 95.4,55.08 U10.E8 ; U11.G8 U11.F9 114.08,54.28 114.46,54.65 v1(114.47,54.65) ; v1(161.26,16.42) 161.01,16.17 U17.5 ; v1(113.66,51.44) 113.26,51.85 U11.J8 ; v1(108.06,51.52) 108.05,51.53 108.11,51.53 U11.J2 ; v1(107.23,57.9) 107.66,57.48 U11.B1 ; v1(114.59,47.72) 114.21,47.72 U11.P9 ; 107.23,55.5 v1(107.23,55.48) ; 107.23,55.5 107.66,55.08 U11.E1 ; v1(151.75,14.86) 152.45,14.17 U17.13 ; U9.P1 v1(71.94,47.88) ; U9.E8 78.09,55.08 v1(78.48,55.47) 78.08,55.87 U9.D8 ; v1(89.19,47.84) 89.71,47.84 U10.P1 ; v1(153.91,37.87) 155.73,37.87 156.22,37.38 U14.32 ; U11.G1 107.62,53.48 107.23,53.08 v1(107.23,53.07) ; U8.P1 54.53,47.83 v1(54.03,47.83) ; U10.J2 90.15,51.47 90.15,51.44 v1(90.15,51.43) ; U11.B3 109.26,57.48 v1(108.86,57.08) ; v1(89.3,57.9) 89.32,57.9 U10.B1 ; v1(94.12,55.48) 94.52,55.08 U10.E7 ; U8.E1 54.55,55.08 v1(54.15,55.48) ; U10.D3 v1(90.95,55.48) U10.E2 ; U11.A9 114.1,58.28 v1(114.47,57.9) 114.06,57.49 U11.B9 ; U10.M9 96.19,49.51 v1(96.68,49.51) ; U9.D3 v1(73.68,55.48) U9.E2 ; v1(95.75,51.52) 95.4,51.88 U10.J8 ; v1(73.68,57.88) U9.B3 ; U17.15 156.68,11.59 ; v1(61.5,49.5) 61,49.5 U8.M9 ; U9.E7 77.24,55.08 v1(76.85,55.47) ; v1(152.21,17.66) 152.23,17.66 154.22,15.67 U17.10 ; U9.G1 72.45,53.48 72.05,53.08 v1(72.05,53.07) ; v1(72.88,51.52) 72.88,51.53 72.93,51.53 U9.J2 ; U10.P9 v1(96.68,47.88) ; U9.G8 U9.F9 78.9,54.28 79.28,54.65 v1(79.29,54.65) ; v1(54.97,51.43) 54.97,51.44 54.97,51.47 U8.J2 ; v1(90.95,57.08) U10.B3 ; v1(107.06,49.48) U11.M1 ; U8.T9 v1(60.97,45.74) ; U9.G9 v1(79.29,53.07) ; v1(89.32,55.48) 89.72,55.88 U10.D1 ; v1(107.03,46.28) U11.T1 ; U9.T9 v1(79.41,46.28) ; v1(114.47,53.07) U11.G9 ; U8.B1 54.57,57.48 v1(54.15,57.9) ; U8.D8 v1(60.57,55.48) U8.E8 ; U8.M1 v1(54.04,49.48) ; v1(61.5,47.88) U8.P9 ; Q19.1 v1(164.47,30.81) ; U8.T1 v1(54.04,46.28) ; v1(114.59,46.28) U11.T9 ; U17.16 157.18,11.52 ; v1(89.22,49.48) U10.M1 ; U11.E8 113.27,55.08 v1(113.66,55.47) 113.26,55.87 U11.D8
  TOP w0.33: v1(89.32,55.48) 89.72,55.08 U10.E1 ; v1(54.13,56.32) 54.57,55.88 U8.D1
  TOP w0.356: Q11.4 51,70.99 50.15,71.84 v1(50.15,73.23) ; Q11.1 52.3,72.45 52.81,72.95 v1(53.02,72.95) ; v1(40.72,14.52) 41.09,14.16 PC62.1 ; PQ9.4 39.68,24.29 40.31,23.66 v1(40.66,23.66) ; v1(36.78,25.58) 36.79,25.59 PQ9.1 ; Q19.4 163.17,27.82 163.04,27.69 C242.1
  TOP w0.381: R29.1 71.22,97.83 R35.1 70.73,97.57 v1(70.57,97.41) ; v1(151.65,22.1) 150.62,22.1 L5.2 ; R32.1 83.82,96.66 C14.2 84.71,96.66 v1(85.49,95.88) ; v1(25.97,40.9) 26.25,40.62 C179.1 ; D3.2 21.2,78.82 v1(20.89,78.5) ; v1(115.59,22.15) 115.59,22.09 115.79,21.89 C266.2 ; v1(23.46,88.09) 23.92,87.63 C54.1 ; C186.1 C187.1 C188.2 v1(36.64,39.07) ; C58.2 71.22,87.22 v1(71.64,87.64) ; C72.2 94.58,86.35 93.8,85.57 C71.2 ; v1(106.33,24.59) 106.99,24.59 PC47.2 ; v1(32.07,43.99) 31.31,43.99 C170.1 ; ESD4.2 110.6,21.32 111.31,22.02 v1(112.7,22.02) ; C168.2 v1(83.46,45.54) ; C80.2 94.32,83.08 C90.2 94.32,81.79 v1(93.95,81.42) ; C126.1 C127.1 ; C189.1 20.9,37.45 v1(20.4,36.96) ; C210.1 21.84,33.7 v1(21.86,33.69) ; v1(29.88,40.9) 29.6,40.62 C180.1 ; v1(74.48,98.65) 74.28,98.85 R30.2 ; v1(90.16,98.66) 90.21,98.61 90.21,97.44 90.4,97.26 C13.2 ; PC13.2 128.97,128.66 128.28,129.35 v1(128.28,130.08) ; C136.2 v1(119.37,58.59) ; PC8.1 57.26,129.38 v1(57.56,129.68) ; v1(25.43,77.94) 25.62,78.13 R97.2 ; v1(95.32,89.32) 94.72,88.73 C49.2 ; C201.2 163.39,35.67 v1(163.19,35.87) ; C239.1 230.7,28.09 v1(230.36,28.09) ; v1(44.93,14.81) 44.93,14.44 44.68,14.2 PC61.1 ; C1.1 R2.2 v1(61.45,131.26) ; v1(68.59,91) 67.98,91 C34.1 ; C250.2 v1(195.43,25.51) ; Q20.1 106.75,18.26 106.11,18.9 v1(106.11,19.62) ; PC5.1 114.84,131.04 114.28,131.6 113.81,131.6 v1(113.73,131.68) ; v1(22.74,41.88) 22.74,41.63 22.99,41.38 C176.1 ; v1(72.68,96.6) 72.63,96.55 R39.1 ; PC58.1 38.62,18.07 v1(38.49,17.93) ; C175.2 118.74,43.01 C171.2 118.74,44.19 v1(119.18,44.62) ; v1(226.9,13.15) 226.9,13.75 C278.2 C279.1 ; C12.2 81.78,97.38 v1(80.57,98.59) ; PC33.2 137.21,86.1 v2(136.61,86.7) ; C5.2 72.68,118.28 72.68,117.36 v1(72.68,117.35) ; R265.2 149.02,19.94 v1(148.37,19.94) ; v1(59.84,128.75) 60.13,129.04 C2.1 ; v1(29.86,71.08) 29.86,70.47 R117.2 ; v1(97.11,88.52) 97.11,88.68 97.45,89.02 C44.2 ; R31.2 79.13,98.27 v1(78.71,98.69) ; PR68.1 v1(40.66,23.66) ; C268.1 193.75,19.19 193.99,18.95 195.85,18.95 196.18,19.28 v1(196.18,19.97) 196.31,20.11 R262.1 ; C230.2 206.73,30.1 v1(205.73,30.1) ; C208.2 133.01,35.11 v1(132.57,35.56) 132.05,35.04 C207.2 ; v1(135.48,35.54) 135.29,35.73 C195.2 D6.1 ; v1(135.48,35.54) 135.98,35.04 R215.2 ; v1(135.48,35.54) 135.02,35.08 C209.2 ; C53.1 C52.1 31.37,87.59 v1(31.37,87.06) ; v1(79.95,96.68) 79.78,96.85 R36.1 ; PC7.1 v1(52.58,130.81) ; R33.2 85.15,98.22 v1(84.71,98.66) ; R43.1 R41.1 72.86,95.53 v1(72.96,95.43) ; v1(83.65,95.04) 83.65,94.79 84.31,94.13 C16.2 ; C45.1 82.53,88.7 v1(81.85,88.7) ; R217.2 200.02,33.98 C214.2 ; v1(88.33,77.11) 87.63,76.41 R102.2 ; v1(206.26,41.75) 206.1,41.75 205.64,41.29 R172.2 ; C166.2 v1(83.46,48.27) ; C164.1 85.02,49.35 v1(85.14,49.48) ; C229.2 v1(196.19,30.54) 195.72,30.54 C228.2 ; v1(151.46,23.95) 151.07,23.56 R254.2 C256.2 ; v1(203.98,35.04) 203.98,34.64 R216.2 ; PR212.2 v1(69.33,138.73) ; v1(68.57,88.75) 68.31,88.49 C47.1 ; R70.1 32.88,85.55 v1(32.37,85.05) ; v1(229.78,25.84) 229.86,25.76 230.73,25.76 C248.2 C244.1 230.74,26.94 v1(230.3,27.38) ; C261.2 196.04,23.46 v1(195.69,23.8) 196.04,24.15 C257.2 ; C215.1 22.74,32.98 23.23,33.47 v1(23.35,33.47) ; v1(225.35,28.36) 226.2,28.36 R242.2 ; R155.1 100.6,53.31 101.34,54.05 C151.1 102.25,54.17 v1(102.48,53.94) C150.1 ; PR61.1 v1(41.8,25.96) ; v1(133.71,37.54) 133.97,37.28 R207.2 ; C162.1 v1(51.27,49.22) ; R239.1 208.87,29.29 v1(208.5,28.92) 208,28.42 C237.1 ; PR8.1 v1(53.68,130.81) ; C241.2 192.64,26.37 v1(192.81,26.2) 192.92,26.08 193.75,26.08 C247.1 ; C245.2 195.48,26.61 v1(195.39,26.52) ; v1(43.86,31.14) 43.74,31.02 PQ8.1 ; C253.2 188.08,24.47 v1(188.75,24.47) 190.48,24.47 C254.2 ; C96.2 93.73,79.22 92.8,79.22 92.19,79.82 v1(92.03,79.82) ; U1.4 v1(68.08,126.22) ; C448.2 25.78,30.18 25.32,29.73 v1(25.32,29.35) ; R91.2 90.67,80.06 91.05,80.45 v1(91.14,80.45) 91.29,80.45 91.95,81.12 C93.2 ; ESD5.2 215.86,18.97 216.09,19.21 216.09,19.42 v1(216.53,19.85) ; R55.1 R57.1 R59.1 70.89,90.05 v1(70.55,90.05) ; PC53.1 v1(38.59,21.11) ; PC6.2 v1(117.46,129.63) ; PC42.2 38.61,27.76 v1(38.16,27.31)
  TOP w0.508: v1(30.07,42.17) 29.84,41.93 Y2.4 ; v1(74.66,84.67) 75.03,84.3 R83.2 ; PC40.2 89.42,29.23 v1(90.1,29.92) ; R61.2 74.34,89.02 v1(74.85,88.51) ; v1(28.24,80.8) 27.86,81.18 Q6.1 ; v1(161.87,31.28) 161.99,31.16 C221.1 ; R225.2 C212.2 v1(33.58,32.77) ; PC39.2 102.97,32.31 103.04,32.24 v1(103.04,31.75) 103,31.71 PR47.2 ; PR25.1 PC16.1 v1(58.36,125.16) ; PC45.2 v1(45.88,26.97) ; C153.2 C148.2 67.79,54.63 v1(67.17,54.02) ; C222.2 C217.2 ; C217.2 R221.1 ; C217.2 152.13,32.62 v1(151.68,32.17) ; HOLE15.6 12.46,-2.05 HOLE15.5 14.25,-0.26 HOLE15.4 HOLE15.1 ; HOLE15.6 HOLE15.1 ; HOLE15.6 9.94,-2.05 HOLE15.7 8.15,-0.26 HOLE15.8 HOLE15.1 ; v1(162.18,12.92) 161.55,12.92 C280.2 ; v1(20.89,75.56) 21.09,75.35 Q9.1 22.59,74.5 U5.2 ; C98.1 86.59,79 v1(86.38,79.21) ; C196.1 152.63,35.88 v1(151.97,35.22) ; PC32.2 v1(146.55,82.63) ; CN2.3 v1(14.69,18) ; v1(80.98,81.2) 81.29,81.2 81.87,80.61 C95.1 ; R47.1 25.68,93.29 25.32,92.93 v1(24.23,92.93) ; C144.1 C145.1 v1(22.67,56.01) ; v1(120.46,90.13) 120.07,89.74 C40.1 ; PC46.1 v1(44.22,26.96) ; U7.2 25.01,55.33 25.37,55.7 26.89,55.7 v1(27.12,55.47) ; v1(17.29,87.35) 17.29,88.16 17.59,88.46 ESD1.2 ; C127.1 28.56,58.71 v1(28.45,58.6) ; v1(76.77,91.41) 76.32,90.96 R58.1 ; C104.2 102.07,75.26 v1(101.69,74.88) ; PR3.2 129.27,137.1 v1(129.51,137.34) ; v1(15.71,72.63) 15.91,72.43 D4.1 ; CN2.6 v1(16.7,25.5) ; v1(20.89,88.43) 21.28,88.83 21.28,89.12 21.83,89.66 C42.2 C43.2 ; PQ3.1 42.83,90.12 v1(42.49,90.46) ; v1(12.81,85.93) 13.44,85.93 C75.1 ; v1(151.27,16.82) 151.04,16.82 150.79,16.57 C277.2 ; C205.2 138.54,35.42 v1(138.54,36.48) ; C99.1 94.38,77.89 v1(94.91,78.42) ; PR37.2 v1(144.98,90.04) ; PQ24.1 v1(67.55,138.79) ; v1(95.75,92.35) 96,92.1 C30.2 ; C235.1 230.39,28.77 v1(230.32,28.85) ; PQ1.1 140.68,92.92 140.22,92.46 v1(140.22,91.95) ; D5.1 16.07,69.72 v1(15.71,69.36) ; C10.1 37.48,101.64 v1(37.11,102.01) ; v1(74.81,86.64) 74.35,86.18 R72.2 ; v1(106.77,123.94) 106.24,123.41 PC19.1 ; v1(28.24,79.76) 27.99,79.51 Q8.1 ; v1(64.95,81.67) 65.02,81.74 C91.1 ; C134.1 65.92,58.09 v1(65.31,57.48) ; PC2.2 131.95,132.34 v1(132.42,132.81) ; C265.1 230.69,21.93 v1(229.78,22.84) ; v1(108.42,28.89) 107.82,28.28 PC41.2 ; HOLE14.9 30.67,10.4 HOLE14.8 33.19,10.4 HOLE14.7 ; v1(210.37,32.11) 210.81,32.55 C216.2 ; v1(14.82,57) 17.01,57 Q13.1 ; R173.1 24.36,41.75 v1(24.9,42.3) 25.32,41.88 C177.1 ; Y2.2 v1(25.64,43.63) ; C158.1 v1(86.48,52.02) ; v1(65.31,57.48) 64.91,57.88 C133.1 ; v1(65.31,57.48) 64.91,57.07 R149.1 ; R235.1 210.5,31.41 v1(210.86,31.04) ; C190.1 152.24,36.87 v1(151.97,36.87) ; v1(100.7,81.11) 100.37,81.11 100.2,81.27 C94.1 ; PQ25.1 63.74,138.89 v1(63.87,139.02) ; R233.1 131,31.71 130.61,32.1 Q17.1 130.61,34.27 v1(130.6,34.38) ; R34.1 C11.2 88.47,98.49 v1(88.31,98.65) ; PR211.2 64.85,134.48 v1(64.38,134.96) ; PQ10.1 v1(30.75,21.04) ; C242.1 163.04,26.67 163.31,26.4 163.31,25.46 v1(163.46,25.3) ; v1(13.94,57.87) C137.1 C128.1 v1(13.94,58.88) ; C182.1 200.65,40.08 v1(200.4,40.32) ; v1(138.17,92.68) 137.53,92.68 PC31.2 ; Q1.1 62.63,130.64 v1(62.63,130.64) ; v1(71.56,85.45) 71.95,85.84 R73.1 ; PC28.2 59.41,120.38 v1(59.85,120.81) ; PC14.2 73.71,125.55 73.27,125.99 v1(73.27,126.67) ; C246.2 v1(17.63,27.1) ; R493.2 139.93,36.54 v1(140.07,36.4) 140.07,35.65 R210.2 ; PD6.2 v1(78.47,15.07) ; PC59.2 v1(46.84,16.34) ; v1(147.41,88.61) 146.93,88.13 PR38.2 ; PQ23.1 63.23,121.87 62.77,122.33 v1(62.11,122.33) ; C138.2 v1(12.77,58.77) ; v1(36.71,19.69) 36.14,19.12 PC55.1 ; v1(208.62,42.58) 208.62,42.14 R169.2 ; 102.5,125.65 PR21.2 103.61,124.29 103.99,123.91 PC17.1 ; C155.2 19.49,52.79 v1(19.38,52.68) ; PC56.2 76.78,19.52 v1(76.99,19.73) 77.19,19.52 PC57.2 ; C226.2 C227.1 v1(34.87,29.82) ; PQ7.1 64.61,31.85 62.7,29.95 ; C178.1 32.77,41.19 v1(32.77,41.19) ; C76.2 C73.2 89.57,86.44 v1(89.82,86.44) ; PQ2.1 v1(144.68,92.44) ; R162.1 v1(82.15,49.35) ; PD5.2 v1(75.55,15.07) ; PR77.1 v1(72.88,18.61) ; PR20.2 v1(119.88,125.18) ; C206.2 v1(142.46,35.98) ; C143.2 85.84,57.47 v1(85.63,57.68) 85.84,57.88 C132.1 ; PQ5.1 v1(35.14,76.36) ; v1(91.21,76.97) 91.65,76.97 92.05,76.57 C101.2 ; v1(114.67,29.16) 114.64,29.14 R241.2 ; v1(101.14,77.87) 100.48,77.21 C100.1 ; C103.2 90.32,76.54 R101.2 89.73,76.61 v1(89.35,76.99) ; PC18.1 108.63,122.84 v1(108.63,122.83) ; C238.2 v1(19.04,27.92) ; v1(144.64,37.93) 145.08,37.93 145.53,37.48 C194.2 ; U18.2 v1(221.9,14.09) ; v1(217.64,32.49) 217.42,32.26 C218.2 ; PR31.2 v1(107.29,121.61) ; v1(83.33,52.02) 83.33,52.02 C157.2 ; C232.2 v1(19.04,29.62) ; C273.1 v1(227.57,18.5) ; PR18.2 v1(119.99,126.32)
  IN3 w0.203: v1(70.55,90.05) 71.26,90.05 72.38,88.93 74.43,88.93 v1(74.85,88.51) 74.93,88.58 77.37,88.58 v1(77.47,88.69) 78.19,87.97 78.19,87.5 77.89,87.2 74.39,87.2 73.93,87.66 71.66,87.66 v1(71.64,87.64)
  IN3 w0.254: v1(71.64,87.64) 71.64,87.74 70.98,88.4 68.92,88.4 v1(68.57,88.75) 68.57,90.03 69.25,90.71 69.96,90.71 70.55,90.12 v1(70.55,90.05)
  BOTTOM w0.089: U21.BH21 95.17,76.01 95.17,76.33 95.13,76.38 95.13,76.38 94.99,76.52
  BOTTOM w0.102: 94.8,77.12 94.8,76.74 94.99,76.55 94.99,76.52
  BOTTOM w0.127: v1(74.98,80.84) 75.05,80.77 U21.AV62 U21.AV61 ; U21.BA2 104.76,79.26 104.88,79.38 U21.BA1 105.43,79.38 v1(105.55,79.26)
  BOTTOM w0.152: U21.BA63 75.56,79.38 75.68,79.26 U21.BA62
  BOTTOM w0.178: PU13.11 145.02,54.36 145.02,54.35 v1(145.02,54.08) ; PU7.11 115.35,114.38 v1(115.32,114.36)
  BOTTOM w0.203: v1(94.08,98.76) 93.91,98.58 U21.A24 ; U21.C48 82.87,97.42 82.87,97.94 82.78,98.02 U21.A48 ; U21.C40 U21.A40 86.49,98.53 v1(86.39,98.63) ; v1(117.73,35.04) 117.45,34.76 U32.21 ; v1(102.21,29.45) 102.44,29.21 PU15.1 ; U21.U62 76.11,90.57 75.44,90.57 U21.U63 ; U21.BF32 90.8,77.02 90.85,76.97 v1(91.21,76.97) ; U21.BJ56 78.66,75.35 78.66,75.28 v1(77.9,74.52) ; v1(116.33,26.94) 116.64,27.26 U32.42 ; v1(120.44,30.8) 120.39,30.74 U32.31 ; PU15.14 103.12,25.16 v1(103.07,25.12)
  BOTTOM w0.229: PU4.4 94.69,136.64 v1(94.5,136.83) ; v1(106.44,80.41) 106.44,80.41 106.11,80.73 105.42,80.73 105.38,80.69 104.7,80.69 U21.AV2 U21.AV3 ; PU3.4 77.74,136.85 v1(77.63,136.96)
  BOTTOM w0.254: U21.AJ2 103.46,84.95 103.2,85.21 U21.AH5 ; CN17.17 215.85,19.44 215.31,19.98 v1(215.2,19.98) ; C447.2 15.59,11.93 v1(15.77,12.11) 15.92,12.25 15.92,16.99 19.01,20.08 21.74,20.08 v1(22.31,20.65) v1(26.07,24.41) 28.07,26.42 v1(28.07,28.09) 28.07,29.13 28.4,29.45 28.4,30.57 28.55,30.72 v1(28.94,30.72) 28.94,29.72 v1(29.35,29.31) 29.35,27.93 v1(29.28,27.85) 29.28,26 v1(26.89,23.62) v1(23.31,20.04) 22.21,18.94 19.48,18.94 17.06,16.52 17.06,11.78 v1(16.58,11.3) 15.08,9.8 14.44,9.8 13.95,10.29 13.95,11.68 v1(14.2,11.93) ; U21.BJ10 100.4,75.48 100.4,75.02 v1(100.47,74.96) ; CN11.4 228.19,28.95 227.85,29.29 v1(227.85,29.84) ; U21.BJ60 77.09,75.41 v1(76.7,75.02) ; U21.AB59 77.2,88.27 77.47,88.55 v1(77.47,88.69) 77.47,88.88 U21.Y59 ; v1(86.81,74.71) 86.81,74.91 87.02,75.13 87.02,75.82 U21.BH39 ; U21.AT35 88.63,81.48 88.41,81.48 v1(88.34,81.41) 88.36,81.41 88.8,80.97 U21.AV35 ; U21.C12 U21.A12 99.47,98.51 v1(99.79,98.83) ; Q24.1 v1(104.49,110.47) ; CN11.7 227.94,27.45 227.75,27.26 227.75,26.17 227.72,26.14 ; 131.21,32.96 Q33.1 132.84,32.96 133.46,32.34 C402.1 ; U21.BA2 104.42,79.07 104.15,78.8 U21.BB3 ; Q25.4 v1(109.35,106.35) ; U21.A5 102.75,98.22 v1(103.1,98.57) ; U21.U1 U21.U2 102.88,90.51 U21.U5 ; U21.AV32 U21.AU32 U21.AR32 ; U21.AV32 U21.AY32 ; U21.AV32 90.32,80.59 U21.AW30 90.92,80.23 v1(91.14,80.45) 91.27,80.45 91.6,80.77 U21.AV29 91.62,80.97 91.62,81.63 U21.AT29 ; CN11.10 228.88,25.96 229.66,25.96 v1(229.78,25.84) ; U21.A52 80.93,98.23 v1(80.57,98.59) ; U21.BH25 93.55,75.78 93.55,75.04 v1(93.45,74.94) ; v1(130.01,30.78) 129.98,30.81 Q33.4 ; U21.F63 74.84,95.19 v1(74.84,95.13) ; U21.BE29 91.6,77.35 v1(91.21,76.97) 91.54,76.64 U21.BG29 91.68,76.64 92.08,77.04 92.2,77.04 U21.BE27 ; v1(102.17,80.23) 102.49,79.92 U21.AY6 ; v1(79.87,74.79) 80,74.92 U21.BJ54 ; U21.AY32 U21.BA32 U21.BC32 U21.BD32 U21.BF32 U21.BG32 U21.BJ32 90.19,75.47 90.19,74.15 v1(90.1,74.06) ; U21.AY32 90.08,79.88 U21.AW34 89.37,80.59 v1(89.26,80.59) ; U21.BA37 87.85,79.65 88.24,80.04 v1(88.33,80.04) 88.45,80.04 88.8,79.68 U21.BA35 ; U21.A44 84.64,98.59 v1(84.71,98.66) ; v1(74.86,77.11) 74.93,77.19 75.38,77.19 U21.BE63 ; U21.BE1 105.42,77.19 v1(105.64,76.96) ; U21.BE35 88.65,77.39 88.37,77.11 v1(88.33,77.11) ; v1(101.01,98.62) 101.01,98.39 101.22,98.18 U21.A9 101.22,97.8 U21.B9 ; U21.AV9 101.04,80.7 100.7,81.05 v1(100.7,81.11) ; U21.A20 95.76,98.55 v1(95.96,98.75) ; U21.BA62 76.44,78.8 U21.BB61 ; C425.2 133.81,24.35 v1(134.12,24.35) 134.12,25.6 C420.1 ; v1(19.04,27.92) 23.89,27.92 v1(25.32,29.35) 25.96,30 26.35,30 v1(26.8,29.55) 26.8,29.21 25.93,28.35 25.93,26.61 24.66,25.33 18.51,25.33 17.63,26.22 v1(17.63,27.1) ; U21.AJ63 75.38,84.95 74.94,84.95 v1(74.66,84.67) ; 102.2,84.92 102.73,84.92 U21.AK5 102.78,84.04 102.18,84.04 ; v1(90.16,98.66) 90.2,98.62 U21.A32 ; U21.AA63 75,88.65 v1(74.85,88.51) ; v1(80.98,81.2) 80.98,81.44 U21.AT52 ; v1(108.05,110.47) Q25.1 ; v1(91.92,74.68) 91.92,74.88 92.05,75.02 U21.BJ28 ; v1(82.55,98.59) 82.55,98.34 U21.A48 ; v1(81.74,74.71) 81.86,74.83 81.86,75.48 U21.BJ50 ; v1(227.72,26.42) 227.72,26.14 ; 227.72,26.14 227.75,26.12 227.58,25.95 CN12.14 ; U21.BA12 99.91,79.75 100.35,79.75 U21.AY10 100.42,79.75 v1(100.92,79.25) ; v1(74.81,86.64) 74.97,86.8 U21.AE63 ; v1(88.33,77.11) 88.8,76.64 U21.BG35 ; v1(88.33,77.11) 88.24,77.11 87.97,77.39 U21.BE37 ; PU11.18 142.35,79.61 v1(142.28,79.53) ; v1(96.87,74.95) 96.69,75.13 U21.BJ18 ; U21.BJ4 103.31,75.31 103.54,75.08 v1(103.54,74.88) ; v1(92.1,98.64) 92.1,98.16 U21.A28 ; U21.AJ1 105.48,84.95 v1(106.35,85.82) ; v1(88.31,98.65) 88.31,98.15 U21.A36 ; v1(216.53,19.85) 216.28,19.61 216.28,18.99 216.35,18.91 CN17.16 ; U21.BF61 76.57,77.17 v1(76.91,77.51) ; v1(79.66,81.13) 79.33,80.8 U21.AV55 ; U21.BJ36 88.35,75.09 88.24,74.99 v1(88.24,74.67) ; v1(98.48,74.65) 98.48,74.9 98.54,74.96 U21.BJ14 ; U21.BH62 75.53,76.06 U21.BH63 74.79,75.92 v1(74.64,76.07) ; v1(128.28,130.08) 128.26,130.1 PU5.18 ; U21.BD56 79.02,78.31 v1(79.27,78.31) ; U21.J63 74.76,94.22 v1(74.68,94.3) ; v1(105.67,92.7) 105.53,92.56 105.21,92.56 U21.N1 ; U21.BJ8 101.61,74.96 v1(101.69,74.88) ; U21.AN63 74.79,82.5 v1(74.79,82.02) 74.87,82.02 75.09,81.8 75.69,81.8 U21.AT62 U21.AT61 ; Q24.4 v1(105.79,106.35)
  BOTTOM w0.279: CN5.9 39.18,97.85 38.87,98.15 v1(38.35,98.15) 38.03,98.15 37.68,97.81 CN5.15 ; CN15.4 v1(112.7,22.02) ; CN9.18 159.33,40 158.71,40.62 v1(158.71,42.4) ; CN5.57 27.18,98.06 v1(27.04,98.19) ; v1(74.81,92.85) 75.29,92.36 U21.N63 ; R334.1 81.67,102.58 81.81,102.72 Q28.4 ; CN5.27 v1(34.68,95.03) ; v1(59.98,83.34) 60.32,83.69 60.32,84.4 60.12,84.6 U22.2 ; v1(77.4,102.41) 77.26,102.41 77.09,102.58 Q26.4 ; Q28.1 v1(80.51,106.52) ; Q27.4 79.38,102.76 v1(78.88,102.27) ; v1(29.07,98.89) 29.66,98.89 30.18,98.37 CN5.45 ; CN5.21 36.18,95.3 v1(35.93,95.05) ; Q26.1 75.79,106.52 v1(75.78,106.53) ; CN5.51 28.68,97.83 v1(29.07,98.22) ; Q27.1 v1(78.08,106.53) ; 154.19,44.8 154.19,42.96 153.98,42.75 CN9.7 ; CN5.39 v1(31.68,98.62) ; v1(33.56,98.62) 33.18,98.24 CN5.33 ; CN9.51 v1(154.37,31.75)
  BOTTOM w0.305: U11.B9 114.06,57.49 v1(114.47,57.9) ; v1(78.71,98.69) 78.79,98.61 U21.A56 ; U27.A9 107.61,58.28 v1(107.23,57.9) 107.66,57.48 U11.B1 ; 57.14,112.98 57.17,112.95 CN3.6 ; v1(76.85,57.9) U25.B3 ; U8.B9 61.37,57.88 v1(61.38,57.88) ; v1(59.85,120.81) 59.85,120.71 60.1,120.45 CN3.21 ; U26.B3 94.52,57.48 v1(94.12,57.88) ; U10.E8 95.4,55.08 v1(95.77,55.45) ; v1(113.66,51.44) 113.66,51.47 U11.J8 ; CN3.9 61.32,114.45 v1(61.5,114.64) ; U11.E2 v1(108.86,55.48) ; v1(108.86,55.48) U27.E7 ; v1(108.86,55.48) 108.46,55.88 U27.D8 ; U25.E7 v1(73.68,55.48) ; v1(73.68,55.48) U25.D8 ; v1(73.68,55.48) U9.E2 ; v1(112.03,57.9) U27.B3 ; v1(89.22,46.28) U10.T1 ; U9.M9 v1(79.41,49.48) ; U8.M1 v1(54.04,49.48) ; v1(58.9,57.75) 59.17,57.48 U24.B3 ; v1(72.88,51.52) 72.88,51.53 72.93,51.53 U9.J2 ; v1(95.75,53.88) U10.G9 ; U21.Y22 v1(95.32,89.32) 95.69,89.7 U21.V20 ; U27.D1 114.06,55.87 v1(113.66,55.47) 113.27,55.08 U11.E8 ; U8.J2 54.97,51.47 54.97,51.44 v1(54.97,51.43) ; v1(96.68,49.51) 96.19,49.51 U10.M9 ; U27.E1 114.06,55.07 v1(114.47,54.65) ; U10.B9 96.55,57.88 v1(96.56,57.88) ; v1(61.5,111.43) 61.48,111.45 CN3.3 ; U11.J2 108.11,51.53 108.05,51.53 v1(108.06,51.52) ; U8.M9 61,49.5 v1(61.5,49.5) ; U25.D3 77.26,55.88 v1(76.85,55.47) ; U26.E7 v1(90.95,55.48) ; v1(90.95,55.48) U10.E2 ; v1(90.95,55.48) U26.D8 ; v1(79.41,47.72) 79.26,47.88 U9.P9 ; v1(54.03,47.83) 54.53,47.83 U8.P1 ; v1(96.23,45.73) 96.23,46.19 U10.T9 ; v1(95.77,55.45) 96.15,55.83 U26.D1 ; v1(95.77,55.45) 96.15,55.08 U26.E1 ; v1(95.75,51.52) 95.4,51.88 U10.J8 ; v1(90.15,51.43) 90.15,51.44 90.15,51.47 U10.J2 ; U25.E1 78.88,55.07 v1(79.29,54.65) ; U9.G9 v1(79.29,53.07) ; 130.6,33.58 131.21,32.96 ; CN3.24 61.73,121.95 v1(62.11,122.33) ; v1(107.03,47.88) U11.P1 ; U24.D1 v1(60.57,55.48) ; v1(60.57,55.48) U8.E8 ; v1(60.57,55.48) U24.E1 ; U24.E7 v1(55.77,55.48) ; v1(55.77,55.48) 55.37,55.88 U24.D8 ; v1(55.77,55.48) U8.E2 ; v1(107.03,46.28) U11.T1 ; v1(89.22,49.48) U10.M1 ; v1(114.59,49.48) U11.M9 ; v1(61.5,119.08) 61.38,118.95 CN3.18 ; v1(114.59,46.28) U11.T9 ; U21.U59 77.52,90.51 U21.U62 ; v1(78.21,93.35) 78.21,93.43 U21.K57 ; U24.D3 v1(58.95,56.3) ; v1(78.49,51.44) 78.49,51.47 U9.J8 ; U8.T1 v1(54.04,46.28) ; U9.T1 v1(71.94,46.28) ; v1(71.91,49.51) 72.45,49.51 U9.M1 ; v1(61.5,47.88) U8.P9 ; U9.B1 v1(72.05,57.9) 72.43,58.28 U25.A9 ; CN17.20 214.35,16.83 v1(214.1,16.58) 213.85,16.82 CN17.21 ; U26.D3 94.52,55.88 v1(94.12,55.48) ; U8.B1 54.57,57.48 v1(54.15,57.9) 54.52,58.28 U24.A9 ; v1(79.29,57.9) 78.88,57.49 U9.B9 ; U8.G9 v1(60.57,53.88) ; U8.J8 60.52,51.52 v1(60.57,51.52) ; U21.B3 104.42,97.52 U21.B2 104.64,97.74 v1(104.64,99.25) ; U11.P9 114.43,47.88 v1(114.59,47.72) ; v1(114.47,53.07) U11.G9 ; U26.A9 89.67,58.28 v1(89.3,57.9) 89.72,57.48 U10.B1 ; CN3.15 61.38,117.45 61.58,117.25 v1(62.09,117.25) ; U10.P1 89.71,47.84 v1(89.19,47.84) ; v1(107.06,49.48) U11.M1 ; U27.D3 112.44,55.88 v1(112.03,55.47) ; U9.T9 v1(79.41,46.28) ; CN3.12 v1(62.09,115.95) ; U8.T9 v1(60.97,45.74) ; U25.D1 78.88,55.87 v1(78.48,55.47) 78.09,55.08 U9.E8 ; U9.P1 v1(71.94,47.88) ; U10.P9 v1(96.68,47.88)
  BOTTOM w0.356: v1(130.6,34.38) 130.6,33.58
  BOTTOM w0.381: v1(61.5,114.64) 61.84,114.64 62.74,113.74 D11.1 ; v2(136.81,49.52) 134.56,49.52 PC187.2 ; v1(115.96,132.09) 116.23,132.09 PR96.2 ; v1(76.91,77.51) 76.57,77.86 U21.BD61 ; v1(85.75,100.67) 85.71,100.71 R346.1 ; C374.2 v1(51.27,48.2) ; R350.1 93.57,101.35 R341.1 93.53,100.7 v1(93.53,100.69) ; R281.1 65.67,109.9 v1(65.67,109.35) 65.63,109.31 D14.1 ; v1(71.56,85.45) 71.45,85.34 R486.1 ; C445.2 13.41,13.93 v1(13.41,14.41) ; C397.1 203.73,34.79 v1(203.98,35.04) ; v1(49.38,58.58) 49.46,58.65 C356.2 ; C396.2 150.48,35.23 v1(150.83,35.58) 150.48,35.92 C393.1 ; v1(197.24,21.49) 197.78,22.03 C436.2 ; C336.2 70.49,88.11 70.97,87.64 v1(71.64,87.64) ; C156.2 v1(119.37,52.53) ; v1(80.99,102.35) 81.26,102.35 81.4,102.21 R334.1 ; v1(57.59,95.43) 57.45,95.3 C329.1 ; R278.2 62.19,122.41 v1(62.11,122.33) ; R382.2 109.04,88.2 v1(109.04,87.61) ; v1(61.43,109.75) 62.51,109.75 C306.1 ; v1(202.64,37.8) 201.95,37.11 PQ16.6 ; v1(87.51,100.7) 87.63,100.82 R348.1 ; v1(131.78,128.79) 131.57,129 PC85.2 ; R479.1 202.37,18.02 v1(202.06,17.71) ; C376.2 C375.2 119.33,47.22 v1(119.37,47.27) ; R485.1 58.79,74.76 v1(58.91,74.63) ; C406.1 R458.2 110.37,31.89 v1(109.96,31.48) 109.96,31.22 109.78,31.04 C405.1 ; PC175.2 v1(146.42,60.92) ; R286.1 94.18,109.91 v1(94.18,109.93) 93.78,109.53 93.78,109.52 R285.1 ; R338.1 89.56,101.31 R340.1 89.55,100.86 v1(89.4,100.71) ; v1(100.26,136.4) 99.95,136.71 PC67.1 ; C160.1 50.66,52.63 v1(50.59,52.69) ; C328.2 C327.1 54.29,95.3 v1(53.9,95.68) ; 77.68,79.3 77.04,79.3 U21.BB61 ; v1(88.58,100.71) 88.59,100.71 R339.1 ; v1(84.72,100.64) 84.7,100.66 R345.2 ; R411.1 C363.2 102.61,54.07 v1(102.48,53.94) ; R355.1 57.64,99.52 v1(57.17,99.05) ; v1(57.77,101.24) 57.65,101.12 C318.2 ; v1(207.82,40.07) 207.86,40.04 R444.2 ; D12.1 D13.1 62.7,111.31 61.62,111.31 v1(61.5,111.43) ; PC120.2 v1(122.29,114.43) ; R357.2 56.82,98.06 56.84,98.04 v1(57.21,97.67) ; C434.2 v1(191.13,22.65) C435.2 ; v1(49.38,55.73) 49.86,55.73 C147.2 ; C378.2 v1(86.51,45.51) ; PR200.1 v1(38.49,17.93) ; v1(48.7,83.22) 48.89,83.04 PR167.2 ; PC117.2 v1(122.29,115.5) ; PQ15.1 148.26,44.52 v1(147.83,44.09) ; R400.2 D29.2 14.35,74.18 v1(14.17,74) ; R347.1 86.67,100.74 v1(86.63,100.7) ; R342.1 92.4,102.08 v1(91.91,102.56) 91.47,102.12 R349.1 ; R150.1 v1(119.37,55.58) ; v1(83.88,100.67) 83.79,100.76 83.79,101.24 R344.2 ; PC125.2 v1(122.29,113.37) ; C313.1 107.42,103.32 v1(107.59,103.15) ; C162.1 v1(51.27,49.22) ; v1(85.85,104.77) 85.71,104.63 R313.1 ; PC174.2 v1(145.4,60.92) ; C433.2 188.44,22.65 189.33,22.65 C432.2 189.33,22.65 189.75,23.07 v1(189.91,23.07) ; R343.2 82.78,100.9 v1(83.04,100.64) ; R282.1 90.08,109.81 v1(90.08,110.23) ; C330.2 v1(61.61,95.73) ; C168.2 v1(83.46,45.54) ; PC176.2 v1(144.39,60.92) ; C166.2 v1(83.46,48.27) ; R283.1 91.59,109.45 v1(92.08,109.93) 92.55,109.45 R284.1 ; C331.2 59.03,95.36 v1(58.9,95.5) ; U21.AR32 v1(90.2,82.55) ; C136.2 v1(119.37,58.59)
  BOTTOM w0.406: ESD7.3 14.59,63.2 14.5,63.11 14.37,62.98 14.14,62.98 v1(14.06,62.9) ; v1(14.06,67.67) 14.21,67.67 14.36,67.52 ESD6.3
  BOTTOM w0.508: v1(197.01,36.65) 197.68,35.98 PR188.2 ; C352.2 114.06,80.16 v1(114.65,80.76) ; PC100.2 PR128.2 v1(108.55,121.11) ; C357.2 64.9,57.89 v1(65.31,57.48) ; C416.2 133.26,28.66 v1(133.26,29.06) ; v1(62.08,123.53) C283.1 C284.1 ; v1(112.7,22.02) D27.1 ; v1(15.77,87.25) 16.29,86.73 C344.1 ; v1(14.19,72.1) 14.72,72.1 C353.2 D30.2 ; C158.1 v1(86.48,52.02) ; J1.2 v1(186.13,20.63) ; U31.4 109.43,32.9 109.92,33.4 v1(110.02,33.4) 110.02,33.45 110.57,34.01 C398.1 ; 122.59,25.15 122.59,26.33 v1(121.72,27.2) 121.07,27.85 C414.1 ; U19.2 64.76,106.52 v1(64.35,106.12) ; PC119.2 PC124.2 113.13,113.63 113.58,113.23 v1(113.7,113.23) ; C380.2 133.2,43.4 v1(133.2,43.72) ; v1(14.2,11.93) C447.2 ; C386.1 34.74,36.47 v1(34.82,36.56) ; v1(102.27,109.52) 102.27,110.26 102.02,110.51 98.09,110.51 97.86,110.27 v1(97.86,107.82) ; v1(102.27,109.52) Y3.4 ; v1(102.27,109.52) 102.27,106.22 101.98,105.93 v1(101.32,105.93) C310.1 ; CN7.2 v1(162.14,47.85) ; PC82.2 113.73,131.27 v1(113.73,131.68) ; v1(120.43,76.86) 120.23,76.66 U23.2 ; C120.1 54.24,62.42 v1(53.51,63.16) ; SW1.6 v1(141.5,26.63) ; v1(115.59,22.15) 115.58,22.16 D28.1 ; Y4.2 v1(124.24,38.27) ; v1(119.86,123.73) 119.55,124.03 PC95.2 ; PJ2.7 231.44,47.96 233.11,47.96 ; C337.1 25.77,87.18 v1(26.08,86.87) 25.77,86.56 C345.1 ; C446.2 v1(12.59,12.02) ; PC66.1 v1(82.88,137.81) ; C371.1 v1(82.15,49.35) ; v1(113.56,90.56) 112.88,89.87 PR153.2 ; PC195.2 103.1,31.69 v1(103.04,31.75) ; PC199.2 89.98,30.05 v1(90.1,29.92) ; v1(85.14,49.48) R413.1 85.84,48.98 85.86,48.95 C372.2 ; v1(132.42,132.81) 131.95,133.28 PR98.2 ; R287.1 R288.1 v1(96.76,110.07) ; v1(97.86,107.82) 97.86,106.98 98.26,106.58 C309.1 98.82,106.17 v1(98.58,105.93) ; v1(97.86,107.82) Y3.2 ; v1(102.98,23.02) 103.36,23.4 PR199.2 104.5,23.69 PC210.2 ; R335.2 97.27,103.2 R322.2 R491.1 97.28,104.62 97.48,104.83 v1(97.48,104.87) ; v1(148.37,19.94) 149.58,19.94 CN14.30 ; C143.2 85.84,57.47 v1(85.63,57.68) 85.84,57.88 C132.1 ; v1(212.2,39.32) 213.19,39.32 CN10.6 ; U30.2 v1(147.56,35.43) ; C370.1 18.66,51.97 v1(19.38,52.68) ; SW3.2 143.36,31.76 142.75,31.15 v1(142.75,30.61) 142.75,30.36 143.18,29.93 C384.2 ; C340.1 12.94,86.06 v1(12.81,85.93) ; C350.1 7.6,83.36 v1(7.6,82.51) ; C364.2 101.62,53.99 102.43,53.99 v1(102.48,53.94) ; v1(83.33,52.02) 83.33,52.02 C157.2 ; PC160.2 116.52,83.83 v1(116.24,84.11) ; C404.1 122.04,31.72 v1(122.04,32.23) ; PC197.2 100.53,30.58 100.25,30.3 v2(100.25,29.93) ; PC202.2 98.55,29.04 v2(98.17,29.42) ; HOLE11.9 217.69,29.94 CN10.5 ; PC94.2 107.29,124.46 v1(106.77,123.94) 107.29,123.42 PC96.2 ; R412.1 68.49,52.8 C365.2 68.34,54.02 v1(67.17,54.02) ; Q31.1 126.62,34.39 v1(126.93,34.7) ; v1(140.07,36.4) 140.36,36.11 SW3.6 ; PR162.2 v1(146.17,83.9) ; PC167.2 50.62,74.62 v1(50.9,74.9) ; v1(72.96,95.43) 72.81,95.59 R367.2 ; v1(109.6,82.98) 109.64,83.01 C351.1 110.37,83.45 109.61,84.21 C348.1 ; PC161.2 45.21,82.97 v1(44.94,82.7) ; v1(64.79,126.69) C282.1 C281.1 ; U20.25 37.95,104.53 37.16,103.74 v1(37.16,102.7) ; v1(192.81,26.2) 192.05,25.43 R469.2 ; PU9.4 116.01,87.18 115.06,88.13 PU9.2 115.06,90.34 v1(114.85,90.56) ; v1(43.9,86.63) 43.57,86.96 C339.1 C346.1 ; v1(118.5,26.41) 118.58,26.33 C419.1 C426.2 ; v1(10.36,87.61) 10.92,87.05 C343.1 ; PC163.1 144.04,79.24 v1(143.67,79.61) ; v1(106.49,126.59) 106.99,127.08 PC89.2 ; v1(144.96,49.9) 144.51,49.45 PC186.2 ; C342.2 8.79,87.08 v1(8.98,87.27) ; Q30.1 51.62,89.49 v1(51.03,88.9) ; C400.2 v1(122.17,33.52) ; C379.2 v1(51.54,45.13) ; PC166.2 v1(45.7,72.97) ; v1(108.42,28.89) 108.13,28.89 107.82,29.2 PR192.2 ; Y4.4 v1(120.93,35.56) ; PR20.2 v1(119.88,125.18) ; U28.4 v1(144.64,37.93) ; PR198.2 v1(105.65,23.05) ; R364.1 v1(72.68,96.6) ; PC162.2 v1(145.25,78.41) ; PC81.2 v1(112.19,131.04) ; PU12.2 v2(46.14,78.39)
  BOTTOM w0.762: CN16.20 133.25,14.72
  vias: v1(8.36,89.88) v1(8.91,84.87) v1(11.14,18.22) v1(11.57,17.48) v1(12.33,17.48) v1(13.09,17.48) v1(13.83,60.91) v1(14.06,65.68) v1(14.07,65.04) v1(14.74,90) v1(16.02,92.18) v1(16.04,90.61) v1(17.32,69.35) v1(17.4,60.84) v1(18.1,67.15) v1(18.1,64.99) v1(18.1,62.82) v1(18.16,23.94) v1(18.65,24.39) v1(19.16,23.95) v1(19.69,50.55) v1(19.69,49.89) v1(19.69,49.23) v1(19.85,67.15) v1(19.85,64.98) v1(19.85,62.82) v1(19.85,60.65) v1(20.37,85.81) v1(20.37,85.04) v1(20.37,84.28) v1(20.4,58.7) v1(21.26,39.17) v1(22.43,57.74) v1(22.43,57.09) v1(22.73,35.22) v1(23.05,57.28) v1(25.09,102.36) v1(25.63,69.1) v1(25.67,50.19) v1(25.7,48.18) v1(26.17,51.33) v1(26.25,37.44) v1(26.25,35.51) v1(26.25,33.58) v1(26.27,69.1) v1(26.39,53.73) v1(27.27,102.31) v1(27.26,88.07) v1(27.29,18.27) v1(28.09,102.36) v1(28.18,66.76) v1(28.18,63.71) v1(28.18,37.44) v1(28.18,33.58) v1(28.34,88.07) v1(29.7,65.23) v1(30.04,73.05) v1(30.11,37.44) v1(30.11,35.51) v1(30.11,33.58) v1(30.27,102.31) v1(30.31,57.64) v1(30.26,29.29) v1(30.35,27.5) v1(31,57.79) v1(31.09,102.36) v1(31.06,27.5) v1(31.23,66.76) v1(31.23,63.71) v1(31.31,73.79) v1(31.31,73.11) v1(31.59,29.29) v1(32.28,29.23) v1(32.8,57.81) v1(33.27,102.31) v1(33.25,30.06) v1(34.09,102.36) v1(34.43,34.54) v1(36.07,70.9) v1(36.1,59.71) v1(36.27,102.31) v1(36.32,68.97) v1(36.32,67.77) v1(36.31,65.91) v1(36.32,64.7) v1(36.3,62.85) v1(36.32,61.64) v1(37.68,34.6) v1(39.08,70.24) v1(39.08,69.58) v1(39.08,67.18) v1(39.08,66.52) v1(39.08,64.12) v1(39.08,63.46) v1(39.08,61.05) v1(39.08,60.39) v1(41.42,99) v1(41.42,98.24) v1(41.94,98.61) v1(43.55,100.86) v1(43.76,105.37) v1(43.96,103.42) v1(43.97,102.77) v1(45.22,104.35) v1(45.24,95.52) v1(46.1,113.53) v1(46.07,112.87) v1(46.12,110.59) v1(46.11,102.28) v1(46.36,58.58) v1(46.36,57.62) v1(46.36,56.63) v1(46.36,55.53) v1(46.47,104.35) v1(46.67,113.85) v1(47.51,95.65) v1(48.04,102.54) v1(49.38,57.61) v1(49.38,56.62) v1(49.93,95.69) v1(51.08,108.85) v1(51.41,128.07) v1(51.44,127.34) v1(53.09,62.65) v1(53.28,106.13) v1(53.76,108.23) v1(53.84,98.01) v1(53.91,106.13) v1(53.87,98.76) v1(53.97,63.67) v1(54.14,116.63) v1(54.78,116.63) v1(54.78,108.82) v1(55.41,116.63) v1(55.43,108.82) v1(56.05,116.63) v1(56.1,108.8) v1(57.01,27.31) v1(57.23,58) v1(57.24,23.14) v1(57.63,56.33) v1(59.03,133.49) v1(58.99,108.86) v1(59.32,23.63) v1(59.32,22.97) v1(59.7,133.48) v1(59.96,22.97) v1(60.33,81.58) v1(60.46,20.43) v1(60.67,81.02) v1(60.99,81.58) v1(61.6,101.21) v1(61.62,98.74) v1(61.78,30.76) v1(63.23,28.83) v1(64.2,114.43) v1(64.43,74.88) v1(64.76,15.59) v1(65.46,76.68) v1(65.48,74.77) v1(65.62,113.37) v1(65.65,112.58) v1(65.9,15.59) v1(65.98,120.99) v1(66.32,84.9) v1(66.64,120.98) v1(66.61,116.98) v1(66.7,118.94) v1(67.16,113.02) v1(67.42,116.29) v1(67.92,111.93) v1(69.2,130.51) v1(71.73,15.58) v1(72.3,14.83) v1(72.36,15.46) v1(75.12,98.7) v1(75.14,58) v1(75.53,56.59) v1(75.58,53.43) v1(76.95,95.26) v1(77.41,84.92) v1(77.56,85.91) v1(77.7,96.21) v1(77.76,31.58) v1(77.94,30.18) v1(79.01,82.12) v1(79.17,95.85) v1(79.25,136.62) v1(79.26,135.58) v1(79.66,88.72) v1(80.12,77.03) v1(80.4,91.43) v1(80.38,88.74) v1(80.38,85.88) v1(80.47,93.57) v1(81.04,88.7) v1(81.11,91.44) v1(81.8,133.53) v1(81.8,87.76) v1(82.09,95.12) v1(82.12,94.42) v1(82.13,93.71) v1(82.12,93.01) v1(82.19,78.45) v1(82.42,17.97) v1(82.97,33.69) v1(83.08,17.97) v1(83.3,85.7) v1(83.26,85.05) v1(83.35,89.62) v1(83.6,82) v1(83.65,79.29) v1(83.82,72.38) v1(83.82,70.44) v1(83.79,33.69) v1(84.52,79.82) v1(84.49,77.72) v1(84.58,93.04) v1(85.48,122.2) v1(85.5,95.19) v1(85.87,89.35) v1(86.43,81.41) v1(86.67,87.89) v1(87.43,95.17) v1(87.44,87.16) v1(87.44,86.42) v1(88.21,83.54) v1(88.24,72.73) v1(88.29,93.08) v1(88.29,92.27) v1(89.02,83.56) v1(89.18,93.01) v1(89.31,92.32) v1(89.81,90.05) v1(89.82,89.33) v1(89.81,88.61) v1(89.82,87.89) v1(90.1,72.1) v1(91.92,72.78) v1(92.03,94.52) v1(91.99,91.62) v1(92.1,95.87) v1(92.14,82.71) v1(92.44,56.13) v1(92.78,57.71) v1(92.94,90.06) v1(92.94,89.33) v1(92.94,88.61) v1(92.94,87.88) v1(92.99,93.82) v1(92.96,86.42) v1(93.57,53.35) v1(93.74,84.97) v1(93.96,95.04) v1(94.76,73.69) v1(94.88,92.44) v1(95.85,80.64) v1(96.1,136.41) v1(96.1,135.38) v1(96.75,82.05) v1(96.75,80.47) v1(96.75,79.04) v1(96.81,92.31) v1(96.77,79.81) v1(96.87,85.72) v1(96.87,84.27) v1(97.87,82.16) v1(98.06,98.67) v1(98.3,79.84) v1(98.28,79.13) v1(98.28,35.84) v1(98.4,84.93) v1(98.41,22.66) v1(98.87,130.87) v1(99,33.63) v1(99.11,84.93) v1(99.23,95.84) v1(99.32,94.43) v1(99.26,88.58) v1(99.34,87.73) v1(99.38,82.1) v1(99.66,33.63) v1(99.73,22.71) v1(99.94,88.62) v1(99.99,108.03) v1(100,93.26) v1(100.32,100.73) v1(101.05,95.89) v1(101.38,92.43) v1(102.13,85.77) v1(102.2,78.33) v1(102.92,28.2) v1(102.92,27.02) v1(103.41,83.01) v1(103.47,92.42) v1(103.53,88.65) v1(103.52,27.61) v1(103.55,95.1) v1(104.11,28.21) v1(104.11,27.02) v1(104.86,133.61) v1(105.45,19.62) v1(105.57,100.15) v1(105.58,95.08) v1(106.29,78.54) v1(106.6,97.3) v1(107.13,89.98) v1(107.55,100.13) v1(107.77,80.41) v1(108.23,78.54) v1(108.57,114.23) v1(108.6,96.32) v1(108.94,76.96) v1(109.12,98.05) v1(110.07,76.96) v1(110.22,96.44) v1(110.22,91.74) v1(110.17,53.37) v1(110.43,58.09) v1(110.5,106.13) v1(110.46,90.53) v1(110.58,76.57) v1(110.85,56.4) v1(111.14,92.98) v1(111.28,94.91) v1(112.32,129.64) v1(112.66,124.77) v1(112.66,123.27) v1(112.66,121.77) v1(112.74,106.46) v1(113.4,129.63) v1(113.96,38.46) v1(114.16,124.77) v1(114.16,123.27) v1(114.16,121.77) v1(114.33,94.49) v1(114.72,123.98) v1(114.74,93.89) v1(114.67,32.72) v1(114.67,30.94) v1(114.81,38.03) v1(115.29,38.51) v1(115.58,92.8) v1(115.66,124.77) v1(115.66,123.27) v1(115.66,121.77) v1(116.45,32.72) v1(116.45,30.94) v1(116.45,29.16) v1(117.21,17.17) v1(117.28,31.65) v1(117.87,17.17) v1(118.22,32.72) v1(118.22,30.94) v1(118.23,29.15) v1(118.63,38.61) v1(119.22,54.06) v1(119.26,50.6) v1(119.37,54.93) v1(119.37,47.99) v1(119.58,38.09) v1(119.58,37.43) v1(120.03,23.68) v1(120.93,46.15) v1(121.32,47.92) v1(122.06,84.94) v1(122.26,37.09) v1(122.72,84.9) v1(127.24,24.5) v1(127.33,108.31) v1(127.33,106.23) v1(127.39,139.37) v1(127.82,24.26) v1(127.87,132.67) v1(127.86,131.9) v1(127.88,107.27) v1(128.08,139.35) v1(128.42,108.31) v1(128.42,106.23) v1(128.64,132.67) v1(128.65,131.89) v1(130.86,50.04) v1(131.25,49.51) v1(131.89,112.91) v1(132.12,110.47) v1(133.5,45.69) v1(133.82,69.8) v1(133.82,67.77) v1(134.86,21.62) v1(137.2,66.55) v1(137.78,30.8) v1(138.1,29.12) v1(138.43,30.79) v1(138.76,29.12) v1(140.36,44.11) v1(141.17,44.11) v1(141.97,82.26) v1(141.96,81.49) v1(142.01,44.11) v1(142.07,21.16) v1(142.74,82.26) v1(142.75,81.48) v1(142.76,67.59) v1(143,87.42) v1(143.02,21.15) v1(143.29,56.37) v1(143.29,55.61) v1(144.44,44.07) v1(144.88,51.34) v1(144.88,43.24) v1(144.94,21.15) v1(145.25,74.76) v1(145.53,51.34) v1(145.6,21.15) v1(146.51,42.58) v1(146.65,16.72) v1(148.45,25.46) v1(151.09,29.77) v1(151.14,28.78) v1(151.78,33.5) v1(152.78,47.35) v1(153.9,47.35) v1(154.39,48.39) v1(154.82,44.48) v1(154.93,47.35) v1(156.32,46.31) v1(156.27,42.52) v1(156.68,44.49) v1(156.73,35.87) v1(156.73,34.37) v1(156.73,32.87) v1(157.03,27.95) v1(156.98,26.7) v1(157.67,27.95) v1(157.97,35.87) v1(157.97,34.37) v1(157.97,32.87) v1(158.3,27.95) v1(158.74,43.74) v1(158.74,43.06) v1(159.43,32.87) v1(159.47,35.87) v1(159.47,34.37) v1(183.36,20.26) v1(184.01,20.22) v1(192.8,14.56) v1(193.37,38.32) v1(193.56,14.58) v1(194.1,38.26) v1(195.9,32.71) v1(196.28,37.08) v1(196.25,33.28) v1(196.89,33.05) v1(197.06,38.81) v1(197.32,33.58) v1(198.54,14.66) v1(199.25,14.66) v1(200.11,25.2) v1(200.16,26.6) v1(200.39,14.64) v1(201.1,14.64) v1(201.41,27.77) v1(201.41,26.62) v1(201.43,25.2) v1(201.99,25.79) v1(202.6,25.2) v1(202.65,27.77) v1(202.65,26.62) v1(203.74,26.6) v1(203.72,25.23) v1(204.05,14.61) v1(205.85,32.76) v1(206.51,32.76) v1(207.12,14.69) v1(207.89,14.66) v1(213.46,22.69) v1(213.79,37.32) v1(214.11,22.03) v1(214.1,21.37) v1(214.1,20.71) v1(214.73,37.03) v1(217.29,16.77) v1(218.68,39.45) v1(219.44,39.83) v1(220.2,40.09) v1(221.77,16.09) v1(223.62,19.59) v1(224.12,20) v1(224.78,29.3) v1(224.78,28.65) v1(227.06,20.73) v1(227.06,20.07) v1(227.06,19.41) v1(227.72,24.59) v1(227.72,19.77) v1(228,34.09) v1(228,33.43) v1(228.05,35.08) v1(228.7,11.89) v1(229.57,11.89) v1(230.1,34.59) v1(230.53,11.89) v1(230.76,34.59) v1(231.4,11.88) v1(232.45,14.91) v1(232.45,14.23) v1(233.36,33.71) v1(233.76,34.24) v2(1.05,21.83) v2(1.23,15.31) v2(1.53,82.29) v2(1.51,32.29) v2(1.54,26.93) v2(1.51,7.75) v2(1.56,89.48) v2(3.22,111.44) v2(4.03,39.46) v2(4.04,35.17) v2(4.36,0.99) v2(5.07,92.94) v2(6.67,75.95) v2(7.56,58.62) v2(9.02,93.44) v2(9.1,109.9) v2(9.53,55.05) v2(10.46,39.47) v2(10.64,73.31) v2(10.67,61.84) v2(10.97,111.43) v2(12.61,39.21) v2(13.41,107.51) v2(13.41,96.15) v2(13.98,53.12) v2(15.12,110.48) v2(16.74,3.22) v2(19.83,110.45) v2(20.37,95.08) v2(20.52,95.84) v2(20.83,6.41) v2(22.73,98.24) v2(23.49,98.24) v2(24.8,110.48) v2(26.73,10.89) v2(33.24,111.04) v2(35.26,110.99) v2(36.89,11.29) v2(37.66,110.48) v2(42.29,111.7) v2(42.35,11.29) v2(42.61,73.16) v2(43.37,73.16) v2(43.7,108.85) v2(43.7,108.09) v2(43.79,109.61) v2(44.13,73.16) v2(44.44,108.85) v2(45.91,115.25) v2(48.58,38.27) v2(49.05,126.76) v2(49.05,119.14) v2(49.14,37.77) v2(49.22,133.64) v2(49.97,11.29) v2(51.32,16.99) v2(51.33,16.2) v2(52.11,16.98) v2(52.17,16.21) v2(52.92,17) v2(52.94,16.23) v2(57.02,25.77) v2(57.44,26.4) v2(57.59,11.29) v2(57.83,25.76) v2(60.17,140.77) v2(60.57,27.51) v2(60.57,26.75) v2(61.33,27.51) v2(61.33,26.75) v2(61.33,25.99) v2(65.21,11.29) v2(67.79,140.77) v2(69.33,136.17) v2(70.09,136.17) v2(70.47,123.37) v2(70.45,122.45) v2(71.21,125.56) v2(71.82,125.02) v2(72.05,126.01) v2(72.13,113.26) v2(72.39,116.73) v2(72.63,116.03) v2(72.64,112.73) v2(73.05,11.24) v2(75.2,136.17) v2(75.41,140.77) v2(77.52,28.2) v2(77.5,26.63) v2(77.55,29.6) v2(77.99,25.04) v2(78.11,11.28) v2(78.4,26.64) v2(78.52,28.23) v2(78.57,29.61) v2(78.97,23.96) v2(79.15,25.02) v2(79.93,20.95) v2(80.11,25.02) v2(80.25,20.19) v2(80.37,24.01) v2(80.67,20.84) v2(81.01,20.09) v2(81.41,20.77) v2(81.7,23.99) v2(81.8,20.09) v2(82.16,20.87) v2(82.61,133.53) v2(82.64,132.64) v2(82.56,20.09) v2(82.66,131.81) v2(82.69,130.99) v2(82.91,20.86) v2(83.03,140.77) v2(83.3,20.15) v2(83.48,133.51) v2(83.5,132.64) v2(83.53,131.83) v2(83.48,130.99) v2(83.73,117.68) v2(83.73,116.79) v2(83.73,115.98) v2(83.66,20.89) v2(84.05,20.18) v2(84.39,122.13) v2(84.39,121.09) v2(84.42,119.79) v2(84.42,118.6) v2(85.73,11.28) v2(85.95,14.31) v2(86.55,120.32) v2(86.55,119.16) v2(86.55,118.24) v2(86.5,18.51) v2(86.6,122.31) v2(86.57,121.34) v2(86.57,117.28) v2(86.6,116.18) v2(86.63,115.17) v2(87.65,18.51) v2(88.48,137.42) v2(88.79,18.51) v2(89.37,137.42) v2(89.88,18.51) v2(90.08,136.89) v2(90.65,140.77) v2(90.92,136.91) v2(91.11,14.29) v2(95.4,21.94) v2(95.4,21.17) v2(96.17,21.94) v2(96.17,21.18) v2(96.95,21.96) v2(96.95,21.19) v2(97.69,21.9) v2(97.69,21.14) v2(98.27,140.77) v2(98.44,21.93) v2(98.44,21.17) v2(98.73,29.93) v2(98.73,14.29) v2(99.22,21.9) v2(99.22,21.14) v2(99.49,29.93) v2(99.97,21.93) v2(99.97,21.17) v2(100.08,134.29) v2(100.08,133.5) v2(100.08,132.72) v2(100.13,131.83) v2(100.13,131.04) v2(100.8,134.63) v2(100.82,133.81) v2(100.82,133.02) v2(100.82,132.23) v2(100.87,131.34) v2(100.87,130.56) v2(101.23,129.9) v2(101.55,134.27) v2(101.6,131.01) v2(101.61,129.16) v2(102.03,130.06) v2(102.26,128.79) v2(102.38,130.74) v2(102.64,129.52) v2(102.89,131.29) v2(103.05,130.21) v2(103.02,128.79) v2(102.98,120.92) v2(103.51,129.55) v2(103.64,131.27) v2(103.73,130.53) v2(104.25,129.67) v2(104.31,128.81) v2(104.41,131.29) v2(104.47,130.45) v2(104.93,129.36) v2(105.08,130.94) v2(105.13,130.09) v2(105.31,132.41) v2(105.31,131.66) v2(105.27,121.68) v2(105.27,120.92) v2(105.73,130.57) v2(105.69,129.47) v2(106.34,111.56) v2(106.35,14.29) v2(107.18,137.16) v2(107.33,111.56) v2(109.51,119.8) v2(109.51,119.04) v2(109.51,117.64) v2(109.51,116.88) v2(109.51,115.48) v2(109.51,114.72) v2(109.51,113.32) v2(109.51,112.56) v2(113.97,14.29) v2(114.36,107.16) v2(114.53,106.26) v2(114.62,108.06) v2(114.67,137.24) v2(115.45,108.08) v2(116.83,116.33) v2(116.86,112.64) v2(117.6,116.33) v2(117.62,112.64) v2(120.96,140.81) v2(121.59,14.29) v2(122.85,138.99) v2(122.85,137.98) v2(122.85,136.89) v2(125.49,140.8) v2(127.32,109.02) v2(127.47,135.08) v2(127.64,105.51) v2(128.08,134.47) v2(128.08,109.02) v2(128.43,135.18) v2(128.4,105.51) v2(128.5,138.75) v2(128.5,137.99) v2(128.46,137.22) v2(128.46,104.7) v2(130.35,140.74) v2(130.4,86.65) v2(131.06,116.36) v2(131.06,115.55) v2(131.08,114.73) v2(131.08,113.9) v2(131.11,113.06) v2(131.11,111.22) v2(131.1,110.47) v2(131.11,109.72) v2(131.57,86.65) v2(132.49,86.69) v2(132.7,79.23) v2(132.7,78.47) v2(132.7,77.7) v2(132.7,76.94) v2(132.7,76.18) v2(132.66,14.29) v2(133.7,136.23) v2(133.7,128.61) v2(133.7,120.99) v2(133.7,113.37) v2(133.7,105.75) v2(133.7,98.13) v2(134.74,71.63) v2(134.73,70.48) v2(134.7,69.33) v2(134.7,68.34) v2(134.7,67.07) v2(134.7,65.97) v2(136.59,88.88) v2(136.66,87.84) v2(138.18,23.96) v2(138.27,48.49) v2(138.27,45.46) v2(138.95,23.96) v2(139.12,94.76) v2(139.57,50.66) v2(140.09,48.49) v2(140.08,45.46) v2(140.33,50.66) v2(140.28,14.29) v2(141.91,84.03) v2(142.48,84.51) v2(143.04,86.72) v2(143.05,85.44) v2(143.22,84.67) v2(143.46,86.11) v2(146.37,68.71) v2(146.37,67.95) v2(146.74,94.76) v2(146.72,56.26) v2(146.72,55.5) v2(147.9,14.29) v2(150.78,92.3) v2(150.78,88.49) v2(150.78,80.87) v2(150.78,73.25) v2(150.78,65.63) v2(150.78,58.01) v2(151.79,11.35) v2(152.87,52.61) v2(160.49,52.61) v2(162.72,11.25) v2(165.15,50.91) v2(170.34,11.25) v2(174.92,48.99) v2(177.51,46.02) v2(177.96,11.25) v2(185.58,11.25) v2(187.04,41.9) v2(192.48,41.93) v2(193.2,11.25) v2(200.32,41.96) v2(203.47,11.38) v2(207.99,43.72) v2(208.44,11.25) v2(212.05,45.22) v2(216.06,11.25) v2(217.13,47.12) v2(218.17,44.23) v2(219.29,42.09) v2(220.53,46.79) v2(221.3,42.27) v2(222.19,44.38) v2(222.28,48.01) v2(223.54,45.21) v2(223.68,11.25) v2(224.65,45.18) v2(227.14,9.32) v2(228.03,21.21) v2(228.31,24.24) v2(228.31,23.5) v2(228.43,45.32) v2(228.97,45.88) v2(229.02,44.71) v2(229.25,48.04) v2(229.17,46.79) v2(229.64,45.37) v2(229.7,46.16) v2(230.24,46.72) v2(230.87,46.18) v2(231.63,46.54) v2(232.24,9.21) v2(232.45,46.18) v2(234.23,30.36) v2(234.23,26.1) v2(234.23,18.48) v2(234.23,10.86) v2(237.73,46.44) v2(238.73,40.66) v2(238.83,33.87)
