# Allegro board Quanta Z8P DA0Z8PMB8D0 REV D - BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_B_DQ56: length 29.7
  TOP w0.14: v1(112.04,56.28) 112.06,56.28 U11.D7
  IN1 w0.102: v1(112.04,56.28) 112.04,57 112.44,57.39 112.44,58.89 111.34,59.99 111.34,76.83 110.05,78.13 109.94,78.13 v1(109.53,78.54)
  BOTTOM w0.089: 105.85,79.85 104.62,79.85 U21.AY2
  BOTTOM w0.102: 105.85,79.85 106.12,79.57 107.33,79.57 107.41,79.5 107.61,79.5
  BOTTOM w0.127: v1(109.53,78.54) 108.57,79.5 107.61,79.5
M_B_DQ57: length 28.8
  TOP w0.14: v1(109.67,58.68) 109.66,58.68 U11.A3
  IN1 w0.102: v1(109.67,58.68) 109.81,58.82 109.81,72.62 109.69,72.73 109.12,72.73 109,72.86 109,73.06 109.12,73.19 109.39,73.19 109.52,73.32 109.52,73.52 109.39,73.65 108.87,73.65 108.29,74.23 108.02,74.23 107.91,74.34 107.91,74.7 108.03,74.82 108.71,74.82 108.82,74.93 108.82,75.16 108.71,75.28 108.03,75.28 107.91,75.39 107.91,75.62 108.03,75.73 108.71,75.73 108.82,75.85 108.82,76.08 108.71,76.19 108.03,76.19 107.91,76.3 107.91,76.6 v1(108.28,76.96)
  BOTTOM w0.089: U21.BD2 104.76,78.19 105.19,78.19 105.34,78.05
  BOTTOM w0.14: 105.34,78.05 107.2,78.05 v1(108.28,76.96)
M_B_DQ58: length 28.7
  TOP w0.14: v1(109.66,56.29) 109.66,56.28 U11.C3
  IN1 w0.102: v1(109.66,56.29) 109.26,56.68 109.26,58.86 109.51,59.11 109.51,71.11 109.03,71.59 109.03,71.75 109.35,72.08 109.35,72.24 109.19,72.4 109.03,72.4 108.71,72.08 108.54,72.08 108.38,72.24 108.38,72.4 108.71,72.72 108.71,72.88 108.54,73.05 108.38,73.05 108.06,72.72 107.9,72.72 107.62,73 107.62,73.29 107.74,73.4 108.24,73.4 108.37,73.53 108.37,73.74 108.24,73.86 107.74,73.86 107.62,73.98 v1(107.62,76.96)
  BOTTOM w0.14: v1(107.62,76.96) 106.79,77.8 105.08,77.8 U21.BD1
M_B_DQ59: length 28.6
  TOP w0.14: v1(108.86,58.68) U11.A2
  IN1 w0.102: v1(106.96,76.96) 106.59,76.59 106.59,76.38 106.73,76.23 107.2,76.23 107.33,76.11 107.33,75.9 107.2,75.78 106.42,75.78 106.3,75.65 106.3,75.45 106.42,75.32 107.2,75.32 107.33,75.19 107.33,74.99 107.2,74.86 106.42,74.86 106.3,74.73 106.3,74.53 106.42,74.4 107.2,74.4 107.33,74.28 107.33,74.07 107.2,73.95 106.42,73.95 106.3,73.82 106.3,73.62 106.42,73.49 107.05,73.49 107.33,73.21 107.33,72.88 109.22,70.98 109.22,59.1 108.86,58.74 v1(108.86,58.68)
  BOTTOM w0.102: U21.BE2 104.69,77.53 105.98,77.53
  BOTTOM w0.14: 105.98,77.53 106.4,77.53 v1(106.96,76.96)
M_B_DQ60: length 30.1
  TOP w0.14: v1(113.66,57.09) 113.66,57.08 U11.C8
  IN1 w0.102: v1(113.66,57.09) 114.06,57.5 114.06,59.28 111.93,61.41 111.93,77.22 110.83,78.32 v1(110.83,78.54)
  BOTTOM w0.089: U21.AW1 105.96,80.31
  BOTTOM w0.102: 107.61,79.98 106.29,79.98 105.96,80.31
  BOTTOM w0.127: 107.61,79.98 109.39,79.98 v1(110.83,78.54)
M_B_DQ61: length 30.6
  TOP w0.14: U11.B8 113.26,57.5 v1(113.66,57.9)
  IN1 w0.102: v1(113.66,57.9) 113.25,58.31 113.25,58.89 112.98,59.16 112.98,59.32 113.13,59.47 113.13,59.65 112.99,59.79 112.81,59.79 112.66,59.65 112.5,59.65 112.34,59.81 112.34,59.97 112.49,60.12 112.49,60.3 112.35,60.45 112.17,60.45 112.01,60.29 111.85,60.29 111.64,60.51 111.64,77.08 v1(110.18,78.54)
  BOTTOM w0.089: 106.49,79.78 106.18,79.78 105.92,80.04 104.84,80.04 104.57,80.31 U21.AW2
  BOTTOM w0.102: 107.48,79.74 107.44,79.78 106.49,79.78
  BOTTOM w0.127: 107.48,79.74 108.98,79.74 v1(110.18,78.54)
M_B_DQ62: length 29.3
  TOP w0.14: v1(112.03,58.72) 112.46,58.29 U11.A7
  IN1 w0.102: v1(108.88,78.54) 109.29,78.13 109.63,78.13 111.05,76.71 111.05,76.17 110.94,76.05 110.6,76.05 110.48,75.93 110.48,75.72 110.6,75.6 110.94,75.6 111.05,75.48 111.05,75.25 110.94,75.14 110.62,75.14 110.5,75.01 110.5,74.81 110.62,74.68 110.94,74.68 111.05,74.57 111.05,59.7 v1(112.03,58.72)
  BOTTOM w0.089: U21.AY3 104.15,79.56 104.73,79.56 104.84,79.67 105.76,79.67
  BOTTOM w0.102: 107.61,79.26 107.36,79.26 107.25,79.37 106.06,79.37 105.76,79.67
  BOTTOM w0.127: v1(108.88,78.54) 108.16,79.26 107.61,79.26
M_B_DQ63: length 27.7
  TOP w0.14: U11.C2 108.41,56.68 v1(108.03,56.3)
  IN1 w0.102: v1(108.03,56.3) 108.45,56.72 108.45,60.97 107.92,61.5 107.92,71.31 108.12,71.51 108.12,71.67 107.96,71.83 107.8,71.83 107.49,71.52 107.31,71.52 107.16,71.67 107.16,71.85 107.47,72.16 107.47,72.32 107.31,72.48 107.15,72.48 106.86,72.19 106.68,72.19 106.54,72.34 106.54,72.52 106.83,72.8 106.83,72.97 106.67,73.13 106.5,73.13 106.3,72.92 106.14,72.92 106,73.06 106,76.67 v1(106.3,76.96)
  BOTTOM w0.102: 105.46,76.54 105.14,76.85 104.62,76.85 U21.BG2
  BOTTOM w0.14: 105.46,76.54 105.87,76.54 v1(106.3,76.96)
M_B_DQS0: length 32.5
  IN3 w0.102: 88.46,53.99 88.48,53.97 88.49,53.97 88.49,53.97 88.86,53.59 92.97,53.59 93.29,53.92 93.29,54.29 v1(93.47,54.46)
  IN3 w0.114: 88.46,53.99 87.55,54.9 87.55,59.38 91.03,62.86 91.03,68.46 91.23,68.65 91.23,73.59 91.49,73.86 91.73,73.86 v1(91.92,74.05)
  BOTTOM w0.089: v1(91.92,74.05) 91.52,74.45 91.52,74.85 91.77,75.1 91.77,75.65 91.88,75.76 U21.BG28
  BOTTOM w0.14: U26.F3 94.31,54.04 93.42,54.04 93.3,54.16 93.3,54.29 v1(93.47,54.46)
M_B_DQS1: length 35.2
  TOP w0.14: U10.F3 91.35,53.98 91.44,53.89 92.43,53.89 92.82,53.5 92.82,53.26 v1(93.02,53.07)
  IN1 w0.089: v1(93.02,53.07) 92.9,53.07 92.76,53.21 92.76,53.48 92.39,53.85 89.1,53.85 87.73,55.21 87.73,58.69 87.74,58.7 87.74,58.73
  IN1 w0.102: 87.74,58.73 87.74,60.33 92.57,65.16 92.57,75.95 91.91,76.62 91.91,77.29 91.76,77.43 91.76,78.15 v1(92.08,78.46)
  BOTTOM w0.14: v1(92.08,78.46) 91.87,78.46 91.6,78.18 U21.BD29
M_B_DQS2: length 23.5
  IN3 w0.102: 93.69,58.87 93.69,58.84 93.68,58.83 93.68,58.54 93.67,58.44 93.35,57.42 93.3,57.34 93.22,57.26 93.13,57.18 92.71,57 92.62,56.98 92.27,56.98 92.2,56.91 v1(92.2,56.75)
  IN3 w0.114: 93.69,58.87 95.75,60.93 95.75,65.25 96.21,65.71 96.21,67.89 94.35,69.75 94.35,74.41 94.47,74.54 94.55,74.54 94.59,74.49 v1(94.76,74.33)
  BOTTOM w0.089: U21.BJ22 95.16,75.16 95.16,74.73 v1(94.76,74.33)
  BOTTOM w0.102: U26.C7 91.35,56.87 91.46,56.98 91.97,56.98 v1(92.2,56.75)
M_B_DQS3: length 30
  TOP w0.102: v1(93.62,56.58) 93.44,56.76 93.44,56.9 93.69,57.15 94.32,57.15 94.55,56.92 U10.C7
  IN1 w0.089: v1(93.62,56.58) 93.42,56.77 93.42,59.32 93.43,59.33 93.43,59.35
  IN1 w0.102: 93.43,59.35 93.43,59.53 97.51,63.6 97.51,75.45 95.52,77.44 95.52,79.25 94.43,80.33 94.24,80.33 v1(93.97,80.6)
  BOTTOM w0.14: U21.AV25 93.63,80.95 v1(93.97,80.6)
M_B_DQS4: length 31.1
  IN3 w0.102: v1(110.26,56.69) 110.46,56.89 110.92,56.89 111.04,57.01 111.04,58.52 110.8,58.77 110.8,58.86 110.8,58.87 110.8,58.89 ; 108.84,72.77 108.82,72.79 108.81,72.79 106.07,75.54 105.23,75.54 104.47,76.3 101.87,76.3 101.71,76.46 101.18,76.46 100.94,76.7 100.94,77.49 100.73,77.7 100.73,77.93 100.16,78.5 v1(100.16,78.63)
  IN3 w0.114: 110.8,58.89 110.8,60.78 110.02,61.56 110.02,71.59 108.97,72.65 108.9,72.71 108.84,72.77
  BOTTOM w0.102: U27.C7 109.42,56.84 110.11,56.84 v1(110.26,56.69)
  BOTTOM w0.14: v1(100.16,78.63) 99.98,78.81 U21.BB12
M_B_DQS5: length 44.5
  TOP w0.14: U11.F3 109.49,54.04 110.72,54.04 110.85,54.17 110.85,54.41 v1(110.61,54.65)
  IN3 w0.102: 107.29,79.22 107.27,79.22 107.27,79.21 107.21,79.21 107.19,79.19 106.06,79.19 105.72,78.86 105.29,78.86 105.15,79 103.73,79 v1(103.53,79.21) ; 114.97,53.57 114.96,53.59 111.3,53.59 110.81,54.07 110.81,54.45 v1(110.61,54.65)
  IN3 w0.114: 114.97,53.57 115.26,53.57 115.99,54.3 116.54,54.84 116.54,73.8 115.34,75 115.33,75 111.11,79.22 107.29,79.22
  BOTTOM w0.102: v1(103.53,79.21) 103.53,79.13 U21.BB5
M_B_DQS6: length 45.6
  IN1 w0.089: 115.44,54.64 115.42,54.63 115.42,54.61 114.8,53.99 111.32,53.99 111.08,53.75 111.08,53.32 110.83,53.07 v1(110.75,53.07)
  IN1 w0.102: 115.44,54.64 116.28,55.49 116.28,59.79 115.12,60.95 115.12,76.85 111.01,80.96 104.58,80.96 104.03,81.52 103.69,81.52 103.59,81.41 v1(103.59,81.27)
  BOTTOM w0.14: U21.AT5 103.2,81.49 103.42,81.27 v1(103.59,81.27) ; v1(110.75,53.07) 110.85,53.07 111.02,53.25 111.02,53.62 111.24,53.83 112.37,53.83 112.46,53.92 U27.F3
M_B_DQS7: length 29.2
  TOP w0.102: v1(111.55,56.76) 111.71,56.92 112.22,56.92 U11.C7
  IN1 w0.089: v1(111.55,56.76) 111.36,56.94 111.1,56.94 110.86,57.17 110.86,58.46 110.35,58.98 110.35,59.33 110.34,59.34 110.34,59.35
  IN1 w0.102: v1(106.94,78.54) 107.14,78.34 107.14,78.05 107.48,77.72 108.9,77.72 109.36,77.26 109.36,74.51 110.34,73.53 110.34,59.35
  BOTTOM w0.089: 105.39,78.6 105.17,78.39 104.8,78.39 104.74,78.45 U21.BC2
  BOTTOM w0.102: 105.39,78.6 105.74,78.6 106.1,78.96 107.04,78.96 107.11,78.89 107.11,78.72 106.94,78.54 v1(106.94,78.54)
M_B_DQS#0: length 32.5
  IN3 w0.102: 88.62,54.14 88.63,54.12 88.63,54.11 88.95,53.8 92.88,53.8 93.09,54.01 93.09,54.31 92.94,54.46 v1(92.81,54.46)
  IN3 w0.114: 88.62,54.14 87.77,54.99 87.77,59.29 91.25,62.77 91.25,68.37 91.44,68.56 91.44,73.5 91.58,73.64 91.77,73.64 91.92,73.49 v1(91.92,73.41)
  BOTTOM w0.089: U21.BH29 91.59,75.25 91.33,74.98 91.33,74 v1(91.92,73.41)
  BOTTOM w0.14: v1(92.81,54.46) 92.94,54.46 93.06,54.35 93.06,54.06 93.32,53.8 94.46,53.8 94.55,53.7 U26.G3
M_B_DQS#1: length 35.2
  TOP w0.14: v1(92.38,53.07) 92.58,53.26 92.58,53.4 92.33,53.65 91.52,53.65 U10.G3
  IN1 w0.089: 87.55,58.7 87.55,58.69 87.55,55.14 89.02,53.67 92.31,53.67 92.58,53.4 92.58,53.26 v1(92.38,53.07)
  IN1 w0.102: 87.55,58.7 87.54,58.7 87.54,60.42 92.37,65.24 92.37,75.87 91.7,76.53 91.7,77.2 91.56,77.35 91.56,78.66 v1(92.07,79.17)
  BOTTOM w0.14: v1(92.07,79.17) 91.95,79.17 U21.BB29
M_B_DQS#2: length 23.5
  IN3 w0.102: 93.47,58.87 93.47,58.85 93.48,58.84 93.48,58.55 93.47,58.48 93.17,57.51 93.14,57.47 93.09,57.41 93.02,57.36 92.64,57.2 92.6,57.19 92.43,57.19 v1(92.2,57.41)
  IN3 w0.114: v1(94.76,74.96) 94.55,74.75 94.46,74.75 94.38,74.75 94.13,74.5 94.13,69.66 95.99,67.8 95.99,65.8 95.53,65.34 95.53,61.02 93.47,58.96 93.47,58.87
  BOTTOM w0.089: v1(94.76,74.96) 94.56,75.16 94.56,75.66 94.84,75.94 U21.BG22
  BOTTOM w0.102: U26.B7 91.35,57.28 91.45,57.19 91.97,57.19 v1(92.2,57.41)
M_B_DQS#3: length 30
  TOP w0.102: U10.B7 94.43,57.36 93.6,57.36 93.23,56.99 93.23,56.86 v1(92.96,56.58)
  IN1 w0.089: 93.23,59.35 93.23,59.33 93.24,59.32 93.24,56.87 v1(92.96,56.58)
  IN1 w0.102: 93.23,59.35 93.23,59.61 97.31,63.68 97.31,75.36 95.32,77.35 95.32,79.16 94.35,80.13 94.16,80.13 v1(93.97,79.94)
  BOTTOM w0.14: v1(93.97,79.94) 93.83,79.8 93.7,79.8 93.47,80.03 U21.AW25
M_B_DQS#4: length 31.1
  IN3 w0.102: 110.59,58.89 110.59,58.88 110.59,58.87 110.59,58.69 110.84,58.44 110.84,57.1 110.83,57.09 110.34,57.09 110.26,57.17 v1(110.26,57.48) ; v1(100.16,77.92) 100.46,77.92 100.53,77.84 100.53,77.62 100.74,77.41 100.74,76.62 101.1,76.26 101.62,76.26 101.78,76.1 104.38,76.1 105.15,75.34 105.98,75.34 108.63,72.69 108.63,72.69 108.67,72.64 108.67,72.63 108.69,72.62
  IN3 w0.114: 108.69,72.62 108.75,72.56 108.75,72.56 109.81,71.5 109.81,61.47 110.59,60.69 110.59,58.89
  BOTTOM w0.102: v1(110.26,57.48) 110.26,57.24 110.08,57.05 109.35,57.05 109.26,57.15 U27.B7
  BOTTOM w0.127: v1(100.16,77.92) 100.16,78.09 100.04,78.21 99.8,78.21 U21.BD12
M_B_DQS#5: length 44.6
  TOP w0.14: U11.G3 109.58,53.8 110.82,53.8 111.1,54.07 111.1,54.48 v1(111.27,54.65)
  IN3 w0.102: v1(102.89,79.21) 102.95,79.21 103.36,78.8 105.06,78.8 105.21,78.65 105.81,78.65 106.15,78.99 107.28,78.99 107.29,79 ; 115.05,53.79 115.03,53.79 115.03,53.79 111.38,53.79 111.02,54.16 111.02,54.4 v1(111.27,54.65)
  IN3 w0.114: 107.29,79 111.02,79 115.24,74.78 115.25,74.78 116.32,73.71 116.32,54.93 115.84,54.45 115.17,53.79 115.05,53.79
  BOTTOM w0.102: U21.BB6 102.49,78.8 v1(102.89,79.21)
M_B_DQS#6: length 45.6
  IN1 w0.089: v1(111.41,53.07) 111.26,53.22 111.26,53.68 111.39,53.81 114.88,53.81 115.55,54.48 115.56,54.48 115.58,54.5
  IN1 w0.102: v1(102.84,81.26) 103.3,81.72 104.11,81.72 104.67,81.17 111.09,81.17 115.33,76.93 115.33,61.03 116.49,59.87 116.49,55.41 115.58,54.5
  BOTTOM w0.14: v1(102.84,81.26) 102.84,81.3 U21.AT6 ; v1(111.41,53.07) 111.27,53.21 111.27,53.49 111.37,53.59 112.34,53.59 U27.G3
M_B_DQS#7: length 29.2
  TOP w0.102: v1(111.54,57.47) 111.54,57.31 111.73,57.12 112.36,57.12 112.46,57.22 U11.B7
  IN1 w0.089: 110.54,59.35 110.54,59.33 110.52,59.32 110.52,59.05 111.04,58.53 111.04,57.25 111.17,57.12 111.36,57.12 111.54,57.31 v1(111.54,57.47)
  IN1 w0.102: v1(107.58,78.54) 107.35,78.3 107.35,78.14 107.56,77.92 108.98,77.92 109.56,77.34 109.56,74.59 110.54,73.61 110.54,59.35
  BOTTOM w0.102: U21.BB1 105.11,78.81 105.67,78.81 106.03,79.17 107.13,79.17 107.32,78.98 107.32,78.69 107.46,78.54 v1(107.58,78.54)
M_B_ODT0: length 39.8
  TOP w0.102: v1(93.29,50.07) 92.88,49.66 92.48,49.66 91.51,50.64 90.68,50.64 U10.K1 ; U11.K1 108.59,50.64 109.41,50.64 110.39,49.66 110.79,49.66 v1(111.19,50.07)
  TOP w0.152: R160.2 86.08,50.65 v1(87.24,50.65) 89.32,50.65 U10.K1
  IN2 w0.102: v1(93.29,50.07) 93.67,50.07 93.91,50.31 96.95,50.31 97.65,51.01 106.76,51.01 107.46,50.31 110.22,50.31 110.38,50.47 110.79,50.47 v1(111.19,50.07)
  BOTTOM w0.102: v1(93.29,50.07) 93.49,50.27 93.88,50.27 94.36,50.75 94.71,50.75 94.8,50.66 94.8,50.51 94.87,50.44 95.03,50.44 95.13,50.53 95.13,50.67 95.21,50.75 95.53,50.75 95.59,50.68 95.59,50.56 95.69,50.47 95.87,50.47 96.15,50.75 U26.K1 ; U27.K1 114.06,50.75 113.78,50.47 113.6,50.47 113.5,50.56 113.5,50.68 113.43,50.75 113.11,50.75 113.04,50.67 113.04,50.53 112.94,50.44 112.78,50.44 112.7,50.51 112.7,50.66 112.62,50.75 112.27,50.75 111.79,50.27 111.39,50.27 v1(111.19,50.07)
M_B_RAS#: length 85.2
  TOP w0.102: v1(111.19,50.88) 110.79,51.29 110.22,51.29 109.72,51.78 109.36,51.78 U11.J3 ; v1(93.29,50.88) 92.88,51.29 92.31,51.29 91.82,51.78 91.45,51.78 U10.J3
  IN1 w0.127: v1(102.33,70.61) 102.1,70.38 102.1,70.13 102.61,69.62 102.61,65.93 102.74,65.81 103.56,65.81 103.69,65.68 103.69,65.43 103.56,65.3 102.74,65.3 102.61,65.17 102.61,64.92 102.74,64.79 103.56,64.79 103.69,64.66 103.69,64.41 103.56,64.28 102.74,64.28 102.61,64.16 102.61,63.9 102.74,63.78 103.56,63.78 103.69,63.65 103.69,63.39 103.56,63.27 102.74,63.27 102.61,63.14 102.61,62.8 102.74,62.67 103.3,62.67 103.43,62.54 103.43,62.29 103.3,62.16 102.74,62.16 102.61,62.04 102.61,61.78 102.74,61.65 103.21,61.65 103.34,61.53 103.34,61.27 103.21,61.15 102.74,61.15 102.61,61.02 102.61,60.77 102.74,60.64 103.21,60.64 103.34,60.51 103.34,60.26 103.21,60.13 102.74,60.13 102.61,60 102.61,59.72 102.74,59.59 103.21,59.59 103.34,59.46 103.34,59.21 103.21,59.08 102.74,59.08 102.61,58.95 102.61,58.7 102.74,58.57 103.21,58.57 103.34,58.45 103.34,58.19 103.21,58.07 102.74,58.07 102.61,57.94 102.61,57.68 102.74,57.56 103.21,57.56 103.34,57.43 103.34,57.18 103.21,57.05 102.74,57.05 102.61,56.92 102.61,56.67 102.74,56.54 103.21,56.54 103.34,56.41 103.34,56.16 103.21,56.03 102.74,56.03 102.61,55.91 102.61,55.65 102.74,55.53 103.21,55.53 103.34,55.4 103.34,55.14 103.21,55.02 102.74,55.02 102.61,54.89 102.61,54.56 102.74,54.44 103.21,54.44 103.34,54.31 103.34,54.04 103.21,53.91 103,53.91 102.87,53.78 102.87,53.43 102.99,53.3 103.21,53.3 103.34,53.18 103.34,52.23 103.04,51.93 v1(102.81,51.93)
  IN2 w0.102: v1(93.29,50.88) 93.49,50.88 93.66,50.71 96.78,50.71 97.99,51.93 v1(102.81,51.93) 102.95,52.08 105.8,52.08 106.21,51.67 106.68,51.67 107.63,50.71 109.81,50.71 110.39,51.29 111.37,51.29 111.47,51.19 111.47,50.99 111.37,50.88 v1(111.19,50.88)
  BOTTOM w0.102: v1(111.19,50.88) 111.57,50.88 111.72,51.03 111.72,51.15 111.58,51.29 111.58,51.41 111.74,51.56 111.98,51.56 112.09,51.45 112.32,51.45 112.46,51.59 U27.J3 ; v1(93.29,50.88) 93.29,51.32 93.77,51.81 93.94,51.81 94.25,51.5 94.45,51.5 94.55,51.6 U26.J3 ; v1(102.33,70.61) 102.54,70.61 103.73,71.81 103.73,73.47 102.8,74.39 102.8,75.32 U21.BJ6
  BOTTOM w0.152: v1(102.81,51.93) 102.54,51.66 102.54,46.81 99.43,43.7 v1(99.43,40.54) R435.2
M_B_WE#: length 85.8
  TOP w0.102: v1(92.65,49.26) 92.5,49.1 92.36,49.1 92.13,49.33 92.13,49.73 92.01,49.85 91.77,49.85 91.68,49.94 91.68,50.17 91.58,50.28 U10.L3 ; U11.L3 109.49,50.28 109.59,50.17 109.59,49.94 109.67,49.85 109.91,49.85 110.04,49.73 110.04,49.33 110.27,49.1 110.41,49.1 v1(110.56,49.26)
  IN1 w0.127: v1(103.33,72.41) 103.33,72.3 103.47,72.16 103.81,72.16 103.94,72.28 103.94,72.79 104.06,72.92 104.32,72.92 104.45,72.79 104.45,72.28 104.57,72.16 105.14,72.16 105.44,71.86 105.85,71.86 105.98,71.73 105.98,71.48 105.85,71.35 105.68,71.35 105.55,71.22 105.55,70.97 105.68,70.84 105.99,70.84 106.12,70.71 106.12,70.46 105.99,70.33 105.68,70.33 105.55,70.21 105.55,60.4 104.83,59.69 104.38,59.69 104.25,59.56 104.25,59.3 104.38,59.18 104.65,59.18 104.78,59.05 104.78,58.8 104.65,58.67 104.38,58.67 104.25,58.54 104.25,58.29 104.38,58.16 104.65,58.16 104.78,58.03 104.78,57.78 104.65,57.65 104.38,57.65 104.25,57.53 104.25,57.27 104.38,57.15 104.65,57.15 104.78,57.02 104.78,56.76 104.65,56.64 104.38,56.64 104.25,56.51 104.25,56.26 104.38,56.13 104.91,56.13 105.04,56 105.04,55.75 104.91,55.62 104.38,55.62 104.25,55.49 104.25,55.24 104.38,55.11 104.93,55.11 105.06,54.99 105.06,54.73 104.93,54.61 104.38,54.61 104.25,54.48 104.25,54.22 104.38,54.1 104.82,54.1 104.95,53.97 104.95,53.72 104.82,53.59 104.38,53.59 104.25,53.46 104.25,53.21 104.38,53.08 104.93,53.08 105.06,52.95 105.06,52.7 104.93,52.57 104.38,52.57 104.25,52.45 104.25,52.19 104.38,52.07 104.93,52.07 105.06,51.94 105.06,51.64 104.93,51.51 104.38,51.51 104.25,51.38 104.25,51.13 104.38,51 104.65,51 104.78,50.88 104.78,50.33 v1(104.05,49.6)
  IN2 w0.102: v1(110.56,49.26) 110.36,49.05 106.91,49.05 106.54,49.43 106.54,50.24 106.44,50.34 106.23,50.34 106.13,50.24 106.13,49.5 106.03,49.39 105.83,49.39 105.73,49.5 105.73,50.24 105.62,50.34 105.42,50.34 105.32,50.24 105.32,49.5 105.22,49.39 105.01,49.39 104.91,49.5 104.91,50.26 104.81,50.36 104.61,50.36 104.51,50.26 104.51,49.5 104.4,49.39 104.25,49.39 v1(104.05,49.6) 99.1,49.6 98.35,48.85 93.06,48.85 v1(92.65,49.26)
  BOTTOM w0.089: U21.BH7 102.13,75.99 102.13,75.28 102.42,75 102.42,74.57 102.13,74.28 102.13,73.9 102.53,73.49 102.78,73.49 103.05,73.22
  BOTTOM w0.102: v1(92.65,49.26) 93.06,49.66 93.32,49.66 93.32,49.66 93.39,49.66 94.54,50.28 U26.L3 ; U27.L3 112.45,50.28 111.3,49.66 111.22,49.66 110.97,49.66 v1(110.56,49.26) ; 103.05,73.22 103.33,72.94 v1(103.33,72.41)
  BOTTOM w0.152: R441.2 105.85,39.79 v1(105.85,41.02) 105.85,46.41 105.76,46.5 105.76,47.49 105.38,47.87 105.38,48.27 v1(104.05,49.6)
M_B_ZQ1: length 5
  BOTTOM w0.14: R413.2 86.21,50.26 86.58,50.63 v1(87.49,50.63) 89.9,50.63 90.06,50.46 90.37,50.46 U26.L8
M_B_ZQ2: length 6.1
  TOP w0.14: U10.L8 95.62,50.55 95.93,50.55 96.05,50.67 96.24,50.67 97.29,51.73 v1(98.87,51.73) 99.91,51.73 R155.2
M_B_ZQ3: length 5
  TOP w0.102: 115.58,50.62 113.63,50.62 113.29,50.28 U11.L8
  TOP w0.14: 115.58,50.62 v1(116.44,50.62) 117.1,51.27 R159.2
M_B_ZQ4: length 5.5
  BOTTOM w0.14: R411.2 v1(105.02,52.19) 106.05,52.19 107.61,50.63 107.8,50.63 107.94,50.49 108.24,50.49 U27.L8
MA_DRAMRST#: length 110.8
  TOP w0.102: U9.T2 73.28,45.46 74.09,43.53 74.35,43.26 74.71,43.26 74.92,43.05 74.92,42.88 74.79,42.75 74.79,42.5 74.94,42.35 75.18,42.35 75.33,42.21 v1(75.33,41.94) ; U8.T2 55.37,45.46 56.18,43.53 56.44,43.26 56.81,43.26 57.02,43.05 57.02,42.88 56.89,42.75 56.89,42.5 57.03,42.35 57.28,42.35 57.42,42.21 v1(57.42,41.94) ; R106.2 C103.1 89.12,76.08 C102.1 88.59,76.57 88.76,76.74 88.76,81.89 88.89,82.01 v1(89.17,82.01)
  IN2 w0.102: v1(57.42,41.94) 57.83,41.53 66.19,41.53 v1(66.32,41.66) 74.99,41.66 75.27,41.94 v1(75.33,41.94)
  IN3 w0.127: v1(89.17,82.01) 88.83,82.01 87.71,83.14 83.87,83.14 83.1,82.37 83.1,81.73 81.2,79.83 79.2,79.83 78.42,79.05 76.71,79.05 75.2,77.53 74.69,77.53 74.38,77.23 74.38,76.84 62.43,64.88 62.43,59.29 61.98,58.84 61.98,49.18 61.06,48.26 61.06,46.64 66.04,41.66 v1(66.32,41.66)
  BOTTOM w0.102: v1(57.42,41.94) 57.83,42.35 58.23,42.35 59.11,43.23 59.82,44.65 U24.T2 ; U25.T2 77.73,44.65 77.02,43.23 76.13,42.35 75.74,42.35 v1(75.33,41.94) ; U21.AR34 89.52,82.37 v1(89.17,82.01)
MAIND: length 245.7
  TOP w0.254: v1(43.34,42.68) 43.61,42.96 43.61,47.54 41.51,49.64 41.51,54.07 43.59,56.15 43.59,66.04 49.63,72.08 49.63,77.35 49.26,77.72 49.26,81.68 51.58,83.99 51.58,86.17 54.68,89.27 54.68,89.72 53.09,91.32 49.74,91.32 49.26,90.84 PQ4.2 ; PQ1.3 PC31.1 137.53,91.42 138.2,90.75 PR35.2 v1(137.39,89.24)
  IN1 w0.254: v1(137.39,89.24) 138.81,90.65 146.4,90.65 148.48,88.56 148.48,87.4 148.09,87 148.09,82.64 148.48,82.24 148.48,50.89 149.71,49.66 149.71,45.67 148.67,44.63 148.67,43 148.45,42.77 148.45,41.28 147.54,40.38 v1(147.54,40.04)
  IN2 w0.254: v1(147.54,40.04) 146.34,40.04 145.62,39.32 140.43,39.32 139.02,40.73 129.2,40.73 128.04,41.89 121.75,41.89 116.41,36.54 114.5,36.54 113.99,36.03 110.08,36.03 107.58,33.53 101.59,33.53 100.45,32.39 49.68,32.39 42.6,39.47 42.6,41.94 v1(43.34,42.68)
MAINON: length 210
  TOP w0.14: v1(132.59,18.47) 132.57,18.47 132.18,18.86 U16.30
  TOP w0.254: v1(126.99,111.39) 125.02,113.37 v1(124.34,113.37) ; v1(134.56,63.86) 139.94,63.86 140.21,63.59 145.8,63.59 v1(146.42,62.97) ; v1(145.87,89.33) PR38.1 146.67,90.68 146.24,91.11 PQ2.2 ; v1(135.79,28.41) v1(135.79,26.28) 136.82,25.25 136.82,23.28 136.08,22.54 136.08,20.76 134.78,19.46 133.68,19.46 132.69,18.47 v1(132.59,18.47)
  IN1 w0.254: v1(135.79,28.41) 136.6,28.41 136.83,28.64 139.08,28.64 139.81,27.91 145.75,27.91 146.77,28.92 146.77,31.92 145.85,32.83 145.85,39.19 148.09,41.43 148.09,42.19 147.13,43.14 147.13,44.1 149,45.97 149,49.37 147.77,50.59 147.77,60.78 146.42,62.13 v1(146.42,62.97)
  IN2 w0.254: v1(135.79,26.28) 135.23,26.84 131.76,26.84 131.51,27.08 122.96,27.08 122.33,27.71 121.51,27.71 121.21,27.41 121.21,26.96 118.01,23.75 117,23.75 115.91,22.66 113.79,22.66 113.66,22.53 109.5,22.53 108.47,23.56 v1(108.47,23.76) ; v1(146.42,62.97) 146.42,63.11 148.51,65.21 148.51,78.66 147.76,79.41 147.76,84.38 145.87,86.27 v1(145.87,89.33)
  IN3 w0.254: v2(129.41,98.21) 130,98.8 130,107.84 128.82,109.02 128.82,110.31 127.74,111.39 v1(126.99,111.39)
  BOTTOM w0.254: PR174.1 146.42,62.97 v1(146.42,62.97) ; R480.1 131.23,15.8 131.69,16.26 131.69,17.86 132.29,18.47 v1(132.59,18.47) ; PR142.1 v1(126.99,111.39) ; v1(134.56,63.86) 131.27,60.57 131.27,57.42 130.33,56.48 130.33,47.65 130.86,47.12 PR182.1 ; PR138.1 v1(124.34,113.37) ; v1(145.87,89.33) 145.87,92.01 144.41,93.47 134.14,93.47 v2(129.41,98.21) ; v1(108.47,23.76) 109.08,23.76 109.54,24.22 109.54,26.78 108.05,28.28 PR193.1
MAINON_ON_G: length 278.7
  TOP w0.14: v1(31.95,74.3) 31.95,75 32.27,75.32 35.89,75.32 36.26,75.68 PQ5.2 36.26,79.94 43.5,87.18 45.02,87.18 45.53,87.69 PQ3.2
  TOP w0.254: v1(144.69,91.72) 144.69,91.14 143.79,90.24 PR37.1 PR36.2 141.21,90.22 PQ1.2 142.07,90.89 142.96,91.78 PQ2.3
  IN1 w0.102: v1(149.93,42.06) 149.49,41.62 149.49,39.55 148.47,38.53 148.47,31.33 147.81,30.67 147.81,28.49 144.3,24.98 141.97,24.98 141.76,25.19 131.46,25.19 129.77,26.89 122.75,26.89 122.07,26.21 121.62,26.21 117.63,22.23 117.63,20.12 114.89,17.38 84.02,17.38 83.23,16.6 68.49,16.6 56.62,28.47 44.12,28.47 v1(41.78,30.81)
  IN1 w0.254: v1(144.69,91.72) 146.33,91.72 149.2,88.86 149.2,51.18 150.42,49.96 150.42,42.56 v1(149.93,42.06)
  IN3 w0.127: v1(31.95,74.3) 31.95,60.68 29.24,57.97 28.56,57.97 25.47,54.88 25.47,51.04 26.19,50.32 26.19,49.05 29.53,45.71 34.75,45.71 35.2,45.26 35.2,39.39 41.78,32.8 v1(41.78,30.81)
  BOTTOM w0.254: v1(149.93,42.06) 149.5,42.49 PQ15.2
MB_DRAMRST#: length 100.5
  TOP w0.102: v1(92.6,41.94) 92.6,42.21 92.46,42.35 92.21,42.35 92.07,42.5 92.07,42.75 92.19,42.88 92.19,43.05 91.99,43.26 91.62,43.26 91.36,43.53 90.55,45.46 U10.T2 ; v1(110.51,41.94) 110.51,42.21 110.36,42.35 110.12,42.35 109.97,42.5 109.97,42.75 110.1,42.88 110.1,43.05 109.89,43.26 109.53,43.26 109.26,43.53 108.46,45.46 U11.T2 ; R105.2 C101.1 90.72,76.8 90.72,78.64 C97.1 89.81,79.55 89.81,81.11 90.09,81.39 90.78,81.39 91.17,81.77 v1(91.17,81.93)
  IN2 w0.102: v1(110.51,41.94) 110.45,41.94 110.17,41.66 v1(101.5,41.66) 101.37,41.53 93.01,41.53 v1(92.6,41.94)
  IN3 w0.127: v1(91.17,81.93) 90.5,81.26 90.5,76.79 91.9,75.39 94.94,75.39 95.18,75.14 95.18,72.96 95.91,72.23 95.91,70.71 98.18,68.44 98.18,52.02 96.22,50.05 96.22,49.41 95.61,48.79 95.61,43.41 97.35,41.66 v1(101.5,41.66)
  BOTTOM w0.102: v1(110.51,41.94) 110.91,42.35 111.31,42.35 112.2,43.23 112.9,44.65 U27.T2 ; U21.AR30 90.73,82.37 v1(91.17,81.93) ; v1(92.6,41.94) 93.01,42.35 93.4,42.35 94.29,43.23 95,44.65 U26.T2
MBCLK: length 148.7
  TOP w0.127: v1(38.58,19.08) 38.58,19.08 PR76.1 ; v1(74.44,20.91) 74.3,20.77 74.3,19.15 74.71,18.74 PR74.2 PC56.1 76.06,17.97 v1(75.97,17.88) 75.55,17.46 PD5.1 ; v1(139.48,26.64) 140.58,27.73 140.58,29.62 140.4,29.8 140.4,30.36 140.28,30.48 U16.110 140.28,32.93 140.14,33.07 140.14,33.61 140.36,33.83 140.67,33.83 141.03,34.19 141.03,36.61 140.78,36.86 140.78,37.49 R206.1
  IN1 w0.102: v1(74.44,20.91) 75.22,21.7 83.5,21.7 85.06,20.13 90.45,20.13 90.98,19.61 102.52,19.61 103.99,21.07 112.75,21.07 113.31,21.64 113.31,22.53 116.15,25.37 117.57,25.37 117.73,25.53 117.73,26.27 120.63,29.17 122.01,29.17 125.45,32.61 126.55,32.61 127.69,31.47 127.69,30.54 128.39,29.84 131.05,29.84 132.23,28.65 133.54,28.65 135.02,27.17 136.94,27.17 137.29,27.52 138.62,27.52 139.48,26.66 v1(139.48,26.64)
  BOTTOM w0.127: v1(74.44,20.91) 74.44,22.68 76.18,24.42 76.18,30.38 74.54,32.02 55.64,32.02 47.15,23.53 43.69,23.53 39.23,19.08 v1(38.58,19.08)
MBDATA: length 144.2
  TOP w0.127: PR70.1 38.56,20.1 v1(38.54,20.12) ; R211.1 140.27,37.33 140.27,36.96 140.78,36.45 140.78,34.32 140.58,34.12 140.19,34.12 139.88,33.8 U16.111 139.88,29.48 140.07,29.29 140.07,27.96 138.82,26.71 v1(138.82,26.64) ; PD6.1 78.47,17.76 v1(78.32,17.91) 77.96,18.27 PC57.1 PR75.2 79.63,19.26 79.63,19.8 78.81,20.62 78.71,20.62 v1(78.46,20.87)
  IN1 w0.102: v1(138.82,26.64) 138.42,27.04 137.49,27.04 137.14,26.69 134.8,26.69 133.33,28.16 132.03,28.16 130.84,29.34 128.18,29.34 127.21,30.32 127.21,31.27 126.35,32.12 125.65,32.12 122.19,28.66 121.56,28.66 117.78,24.87 116.36,24.87 113.81,22.32 113.81,21.43 112.68,20.3 108.7,20.3 107.52,19.12 90.78,19.12 90.26,19.64 79.69,19.64 v1(78.46,20.87)
  BOTTOM w0.127: v1(78.46,20.87) 78.46,22.66 76.69,24.43 76.69,30.61 74.77,32.53 55.41,32.53 46.94,24.06 43.47,24.06 39.53,20.12 v1(38.54,20.12)
MCSI_DPHY1.1_RCOMP: length 2.2
  TOP w0.127: v1(92.06,95.23) 92.27,95.23 92.76,94.75 92.92,94.75 R44.1
  BOTTOM w0.127: U21.H27 92.5,94.79 v1(92.06,95.23)
MCSI_DPHY1.2_RCOMP: length 4.2
  TOP w0.127: v1(93.08,95.15) 93.08,95.23 v1(93.56,95.71) 94.11,95.71 94.67,96.27 95.93,96.27 R40.1
  BOTTOM w0.102: U21.F27 92.73,95.5 v1(93.08,95.15)
MDI_0+: length 77.4
  TOP w0.127: U13.1 24.75,37.71 24.12,38.35 22.47,38.35 22.31,38.52 22.31,38.73 22.38,38.8 v1(22.55,38.8)
  IN3 w0.127: v1(22.55,38.8) 22.42,38.93 22.42,40.06 22.29,40.19 22.29,53.16 21.98,53.47 21.98,58.83 21.38,59.44 21.38,70.74 23.49,72.86 23.49,80.1 24.54,81.15 24.54,91.58 28.38,95.43 31.98,95.43 35.39,98.83 35.39,101.76 v1(35.62,101.99)
  BOTTOM w0.127: U20.2 35.7,101.13 35.6,101.24 35.52,101.24 35.39,101.37 35.39,101.94 35.44,101.99 v1(35.62,101.99)
MDI_0-: length 77.4
  TOP w0.127: U13.2 24.54,37.31 23.94,37.92 22.3,37.92 21.93,38.3 21.93,38.66 v1(21.79,38.8)
  IN3 w0.127: v1(34.75,101.99) 34.75,101.99 34.75,99.1 31.72,96.06 28.12,96.06 23.9,91.85 23.9,81.41 22.85,80.36 22.85,73.12 20.74,71.01 20.74,59.17 21.35,58.57 21.35,53.21 21.66,52.89 21.66,39.93 21.79,39.8 v1(21.79,38.8)
  BOTTOM w0.127: v1(34.75,101.99) 34.75,101.99 34.75,101.02 34.7,100.97 U20.3
MDI_1+: length 83.7
  TOP w0.127: U13.4 24.54,36.51 24.53,36.53 22.56,36.53 v1(22.27,36.82)
  IN3 w0.127: v1(32.67,101.99) 32.43,101.99 32.34,101.91 32.34,100.61 31.01,99.29 31.01,97.69 30.28,96.95 25.15,96.95 20.64,92.44 20.64,91.17 22.99,88.82 22.99,81.75 21.96,80.73 21.96,74.51 20.43,72.98 20.04,72.98 20.04,72.98 19.91,72.98 19.91,72.98 19.03,72.98 18.51,72.46 18.51,69.7 19.24,68.98 19.24,58.71 20.46,57.5 20.46,52.81 20.77,52.5 20.77,38.46 22.27,36.96 v1(22.27,36.82)
  BOTTOM w0.127: U20.5 32.7,101.13 32.58,101.25 32.44,101.25 32.34,101.36 32.34,101.91 32.42,101.99 v1(32.67,101.99)
MDI_1-: length 83.8
  TOP w0.127: U13.5 24.55,36.11 24.53,36.1 22.23,36.1 v1(21.51,36.82)
  IN3 w0.127: v1(31.7,101.99) 31.7,100.87 30.38,99.55 30.38,97.95 30.01,97.59 24.89,97.59 20,92.71 20,90.91 22.35,88.56 22.35,82.01 21.33,80.99 21.33,74.77 20.17,73.61 18.77,73.61 18.4,73.24 17.87,72.72 17.87,69.44 18.6,68.71 18.6,58.45 19.82,57.23 19.82,52.55 20.13,52.24 20.13,38.19 v1(21.51,36.82)
  BOTTOM w0.127: U20.6 v1(31.7,101.99)
MDI_2+: length 84.9
  TOP w0.127: U13.6 24.21,35.71 v1(24.11,35.61)
  IN3 w0.127: v1(29.68,101.99) 29.42,101.99 29.34,101.91 29.34,101.42 28.2,100.28 27.42,100.28 26.21,99.07 22.83,99.07 18.66,94.9 18.66,90.99 19.58,90.06 19.58,89.1 21.45,87.24 21.45,82.37 20.44,81.36 20.44,76.59 16.79,72.94 16.79,58.98 18.93,56.84 18.93,55.05 18.93,37.53 20.16,36.3 23.55,36.3 24.11,35.74 v1(24.11,35.61)
  BOTTOM w0.127: v1(29.68,101.99) 29.4,101.99 29.34,101.93 29.34,101.29 29.4,101.23 29.58,101.23 29.7,101.11 U20.8
MDI_2-: length 85
  TOP w0.127: U13.7 24.51,35.31 24.35,35.15 23.8,35.15 v1(23.43,35.52)
  IN3 w0.127: v1(23.43,35.52) 23.28,35.67 19.9,35.67 18.3,37.26 18.3,55.31 18.3,56.57 16.16,58.72 16.16,73.2 19.81,76.85 19.81,81.62 20.81,82.63 20.81,86.98 18.95,88.84 18.95,89.8 18.02,90.73 18.02,95.16 22.57,99.71 25.95,99.71 27.16,100.92 27.94,100.92 28.7,101.68 v1(28.7,101.99)
  BOTTOM w0.127: U20.9 v1(28.7,101.99)
MDI_3+: length 86.4
  TOP w0.127: v1(24.07,34.31) 24.27,34.51 U13.9
  IN3 w0.127: v1(26.69,101.99) 26.4,101.99 26.33,101.92 26.33,101.35 25.67,100.68 22.29,100.68 17.13,95.53 17.13,90.33 17.85,89.61 17.85,88.39 19.22,87.02 19.92,86.32 19.92,83 18.92,81.99 18.92,77.22 18.55,76.85 18.54,76.85 15.27,73.57 15.27,58.35 17.41,56.21 17.41,55.68 17.41,36.9 19.62,34.69 21.03,34.69 21.1,34.76 23.77,34.76 24.07,34.46 v1(24.07,34.31)
  BOTTOM w0.127: v1(26.69,101.99) 26.41,101.99 26.33,101.92 26.33,101.36 26.42,101.27 26.62,101.27 26.7,101.19 U20.11
MDI_3-: length 86.5
  TOP w0.127: U13.10 24.51,34.11 24.23,33.84 23.72,33.84 v1(23.43,34.13)
  IN3 w0.127: v1(23.43,34.13) 21.37,34.13 21.29,34.05 19.35,34.05 16.77,36.63 16.77,55.94 15.01,57.71 14.63,58.08 14.63,73.31 14.63,73.83 18.28,77.48 18.28,81.73 18.28,82.26 19.29,83.26 19.29,86.06 18.95,86.39 17.22,88.13 17.22,88.65 17.22,89.35 16.5,90.06 16.5,95.79 22.03,101.32 25.41,101.32 25.7,101.61 25.7,101.99 v1(25.7,101.99)
  BOTTOM w0.127: v1(25.7,101.99) 25.7,101.99 25.7,101.11 25.7,101.1 U20.12
MDSI_RCOMP: length 1.3
  TOP w0.254: R87.1 102.08,82.06 v1(101.45,82.06)
  BOTTOM w0.254: v1(101.45,82.06) 101.78,82.39 U21.AP7
ME_WR#: length 161.3
  TOP w0.14: v1(140.57,33.39) 140.68,33.28 U16.109
  IN3 w0.127: v1(50.58,83.92) 49.78,83.11 49.78,82.57 49.27,82.06 49.27,77.82 51.35,75.74 51.35,73.55 44.13,66.33 44.13,44.75 45.41,43.48 45.41,39.82 53.12,32.1 97.51,32.1 97.65,32.24 101.19,32.24 102.07,33.12 103.19,33.12 104.06,32.26 107.69,32.26 108.37,32.94 110.51,32.94 111.14,33.56 113.12,33.56 113.47,33.91 115.97,33.91 118.89,36.83 118.89,38.38 120.27,39.76 124.45,39.76 126.93,37.28 128.11,37.28 129.62,35.76 130.67,35.76 130.8,35.64 130.96,35.64 131.01,35.59 131.48,35.59 132.21,34.86 139.09,34.86 v1(140.57,33.39)
  BOTTOM w0.127: 49.95,86.21 51.19,87.46 Q30.2
  BOTTOM w0.14: 49.95,86.21 49.95,84.56 50.58,83.92 v1(50.58,83.92)
MEM_CH0_RCOMP: length 1.5
  TOP w0.254: R89.1 89.27,81.3 v1(89.17,81.3)
  BOTTOM w0.305: v1(89.17,81.3) 89.37,81.3 U21.AV34
MEM_CH1_RCOMP: length 1.4
  TOP w0.254: R91.1 90.82,80.84 v1(91.14,81.16)
  BOTTOM w0.305: U21.AV30 90.89,81.16 v1(91.14,81.16)
MIC2-VREFO: length 10.5
  TOP w0.203: v1(205.97,25.86) 205.72,25.86 205.58,26 U15.29
  IN3 w0.254: v1(201.84,20.86) 202.37,21.39 202.37,22.25 202.73,22.6 204.94,22.6 205.4,23.06 205.4,25.3 v1(205.97,25.86)
  BOTTOM w0.254: R477.1 201.45,20.47 v1(201.84,20.86) 202.23,20.47 R478.1
MX0: length 43.1
  TOP w0.127: v1(143.32,15.25) 143.08,15.48 U16.58
  IN1 w0.102: v1(175.88,17.4) 175.75,17.4 174.53,18.62 165.59,18.62 164.17,20.05 155.71,20.05 155.1,19.44 152.14,19.44 151.01,18.31 151.01,17.79 148.7,15.47 143.55,15.47 v1(143.32,15.25)
  BOTTOM w0.127: v1(175.88,17.4) 176.11,17.4 179.4,20.69 CN14.1
MX1: length 43.5
  TOP w0.127: v1(144.18,17.57) 143.86,17.57 143.48,17.18 U16.59
  BOTTOM w0.127: CN14.2 178.4,20.71 176.24,18.55 165.87,18.55 164.27,20.15 151.85,20.15 151.2,19.49 151.2,18.02 151.08,17.91 150.18,17.91 147.74,15.47 v1(147.31,15.47) 144.18,15.47 143.99,15.67 143.99,16.37 144.28,16.67 144.28,17.46 v1(144.18,17.57)
MX2: length 39.8
  TOP w0.127: U16.60 143.88,15.56 144.3,15.14 147.01,15.14 147.56,15.69 147.56,16.41 v1(147.86,16.72)
  IN1 w0.102: v1(177.1,20.66) 176.11,19.66 167.75,19.66 167.17,20.25 167.17,20.76 166.86,21.06 155.15,21.06 154.55,20.45 151.7,20.45 149.95,18.7 149.95,18.16 148.5,16.72 v1(147.86,16.72)
  BOTTOM w0.127: CN14.3 177.4,20.96 v1(177.1,20.66)
MX3: length 41.8
  TOP w0.127: U16.61 144.28,15.53 144.41,15.4 146.9,15.4 147.11,15.61 147.11,16.88 147.56,17.33 v1(148.12,17.33)
  BOTTOM w0.127: v1(148.12,17.33) 147.81,17.63 v1(147.81,19.39) 147.81,20.4 148.73,21.32 151.09,21.32 151.32,21.09 151.32,20.58 151.5,20.4 164.45,20.4 165.92,18.93 175.25,18.93 176.4,20.08 CN14.4
MX4: length 37.3
  TOP w0.127: U16.62 144.68,17.38 144.64,17.42 v1(144.64,18.12)
  BOTTOM w0.127: CN14.5 175.4,21.06 173.65,19.31 165.97,19.31 164.63,20.66 151.7,20.66 151.65,20.7 151.65,21.11 151.19,21.57 148.32,21.57 v1(147.51,20.77) 147.31,20.56 147.31,19.26 146.39,18.34 145.99,18.34 145.58,17.94 144.82,17.94 v1(144.64,18.12)
MX5: length 36.1
  TOP w0.127: v1(145.2,18.47) 145.2,18.03 145.27,17.95 145.27,17.34 145.08,17.15 U16.63
  BOTTOM w0.127: v1(145.2,18.47) 145.43,18.47 145.57,18.61 146.28,18.61 147.05,19.39 147.05,20.93 v1(148.06,21.94) 151.19,21.94 151.9,21.22 151.9,21.03 152.02,20.91 164.73,20.91 164.99,20.66 165.98,19.66 173.29,19.66 174.4,20.77 CN14.6
MX6: length 34.8
  TOP w0.127: U16.64 145.48,17.16 145.89,17.58 145.89,18.49 145.32,19.06 v1(145.32,19.31)
  IN1 w0.102: v1(173.4,23.07) 172.61,22.28 154.34,22.28 154.04,21.98 152.5,21.98 152.22,21.7 151.07,21.7 148.88,19.51 147.81,19.51 147.31,19 146.7,19 146.44,18.75 145.91,18.75 145.35,19.31 v1(145.32,19.31)
  BOTTOM w0.127: CN14.7 v1(173.4,23.07)
MX7: length 31.9
  TOP w0.127: v1(145.97,19.31) 146.17,19.11 146.17,18.19 146.3,18.06 U16.65
  IN1 w0.102: v1(145.97,19.31) 147.13,19.31 148.32,20.5 149.19,20.5 151.19,22.51 152.51,22.51 152.84,22.18 153.88,22.18 154.19,22.48 171.82,22.48 v1(172.4,23.07)
  BOTTOM w0.127: CN14.8 v1(172.4,23.07)
MY0: length 31.4
  TOP w0.127: v1(135.37,18.19) 135.36,18.2 135.35,18.2 134.92,18.64 134.37,18.64 134.28,18.54 U16.36
  IN1 w0.102: v1(155.7,24.7) 155.48,24.92 151.23,24.92 148.56,22.25 147.66,22.25 147.19,21.78 142.03,21.78 140.29,20.04 135.98,20.04 135.77,19.84 135.77,18.97 135.37,18.57 v1(135.37,18.19)
  BOTTOM w0.127: CN14.26 v1(154.4,22.99) 154.4,23.46 154.6,23.65 155.33,23.65 155.7,24.02 v1(155.7,24.7)
MY1: length 30.8
  TOP w0.127: U16.37 134.64,16.45 134.64,17.19 134.53,17.3 134.53,17.99 v1(134.74,18.19)
  IN1 w0.102: v1(156.33,24.72) 155.92,25.13 151.15,25.13 148.48,22.46 147.58,22.46 147.1,21.98 141.94,21.98 140.21,20.25 135.47,20.25 134.74,19.52 v1(134.74,18.19)
  BOTTOM w0.127: CN14.25 155.4,23.19 156.32,24.11 156.32,24.71 v1(156.33,24.72)
MY2: length 32.7
  TOP w0.127: v1(135.05,17.58) 135.08,17.55 U16.38
  IN1 w0.102: v1(135.05,17.58) 134.71,17.58 134.25,18.04 134.25,20.25 134.45,20.45 140.12,20.45 141.86,22.19 147.02,22.19 147.4,22.57 147.49,22.66 148.39,22.66 151.06,25.33 156.58,25.33 v1(156.62,25.29)
  BOTTOM w0.127: CN14.24 v1(156.4,22.99) 156.4,23.73 156.78,24.11 156.78,25.13 v1(156.62,25.29)
MY3: length 38.7
  TOP w0.127: v1(135.68,17.59) 135.48,17.38 U16.39
  IN1 w0.102: v1(135.68,17.59) 136.06,17.59 136.43,17.96 136.43,18.45 137.62,19.64 140.46,19.64 141.16,20.34 142.22,20.34 142.63,20.75 146.83,20.75 147.93,21.85 148.73,21.85 151.4,24.52 154.22,24.52 155.02,23.71 159.48,23.71 160.4,24.63 160.4,25.15 v1(160.32,25.23)
  BOTTOM w0.127: v1(160.32,25.23) 160.28,25.27 159.97,25.27 158.95,26.29 157.87,26.29 157.06,25.48 157.06,24.34 157.67,23.73 157.67,23.02 v1(157.69,22.99) 157.4,22.7 CN14.23
MY4: length 35.1
  TOP w0.127: v1(136.01,18.19) 136.18,18.02 136.18,17.45 135.88,17.15 U16.40
  IN1 w0.102: v1(159.9,24.74) 159.73,24.92 159.73,25.51 158.94,26.29 157.67,26.29 157.09,25.71 157.09,24.9 156.47,24.29 154.74,24.29 154.3,24.72 151.31,24.72 151.27,24.68 148.64,22.05 147.74,22.05 147.27,21.58 142.87,21.58 142.61,21.32 142.61,21.02 142.14,20.54 141.08,20.54 140.37,19.84 137.4,19.84 136.05,18.49 136.05,18.24 v1(136.01,18.19)
  BOTTOM w0.127: v1(159.9,24.74) 159.88,24.64 158.4,23.16 CN14.22
MY5: length 36.9
  TOP w0.127: U16.41 136.28,17.17 136.46,17.35 136.46,18.09 136.77,18.39 136.77,21.06 v1(136.84,21.14)
  IN1 w0.102: v1(160.9,24.72) 160.9,26.09 160.06,26.93 157.82,26.93 157.01,26.12 155,26.12 154.42,25.53 150.98,25.53 148.31,22.86 147.41,22.86 147.26,22.71 146.93,22.39 141.6,22.39 140.81,21.6 137.12,21.6 136.84,21.32 v1(136.84,21.14)
  BOTTOM w0.127: CN14.21 v1(159.4,22.99) 159.4,23.22 v1(160.9,24.72)
MY6: length 34.2
  TOP w0.127: U16.42 136.68,17.16 136.77,17.24 136.77,17.7 137.27,18.2 v1(137.27,18.2)
  IN1 w0.102: v1(137.27,18.2) 137.27,18.33 138.17,19.23 140.63,19.23 141.33,19.93 142.49,19.93 142.9,20.34 147,20.34 148.1,21.44 148.9,21.44 150.79,23.34 151.75,23.34 152.52,24.11 153.88,24.11 154.7,23.3 160.62,23.3 v1(162.04,24.72)
  BOTTOM w0.127: CN14.20 160.4,23.36 161.76,24.72 v1(162.04,24.72)
MY7: length 36.1
  TOP w0.127: v1(137.27,17.57) 137.27,17.53 137.08,17.34 U16.43
  IN1 w0.102: v1(137.27,17.57) 136.96,17.57 136.74,17.79 136.74,18.47 137.71,19.43 140.54,19.43 141.25,20.14 142.4,20.14 142.81,20.55 146.92,20.55 148.01,21.64 148.81,21.64 150.71,23.54 151.66,23.54 152.44,24.31 154.13,24.31 154.93,23.51 160.5,23.51 161.53,24.54 161.53,24.97 161.78,25.23 162.42,25.23 v1(162.6,25.05)
  BOTTOM w0.127: CN14.19 v1(161.4,22.99) 161.4,23.37 162.6,24.57 v1(162.6,25.05)
MY8: length 34.2
  TOP w0.127: U16.44 137.48,17.15 137.86,17.53 v1(137.86,17.81)
  IN1 w0.102: v1(163.18,24.72) 161.56,23.09 154.57,23.09 153.83,23.83 152.53,23.83 151.83,23.13 150.9,23.13 149,21.24 148.18,21.24 147.08,20.14 142.98,20.14 142.57,19.73 141.41,19.73 140.71,19.03 138.33,19.03 137.86,18.55 v1(137.86,17.81)
  BOTTOM w0.127: v1(163.18,24.72) 162.4,23.94 CN14.18
MY9: length 33.8
  TOP w0.127: U16.45 137.88,17.16 138.47,17.75 v1(138.47,18.01)
  IN1 w0.102: v1(163.82,24.7) 162,22.89 154.44,22.89 153.76,23.58 152.56,23.58 151.92,22.93 151,22.93 149.11,21.03 148.27,21.03 147.17,19.94 143.07,19.94 142.62,19.49 141.47,19.49 140.79,18.82 139.25,18.82 138.67,18.24 138.67,18.24 138.47,18.04 v1(138.47,18.01)
  BOTTOM w0.127: CN14.17 v1(163.4,23.37) 163.4,24.29 v1(163.82,24.7)
MY10: length 35
  TOP w0.127: U16.46 138.28,17.15 138.93,17.8 v1(139.13,17.8)
  IN1 w0.102: v1(139.13,17.8) 139.13,18.13 139.61,18.62 140.88,18.62 141.55,19.29 143.86,19.29 144.3,19.73 147.25,19.73 147.31,19.79 147.74,20.22 147.82,20.3 148.23,20.71 148.35,20.83 149.21,20.83 151.11,22.73 152.05,22.73 152.67,23.35 153.52,23.35 154.18,22.69 162.67,22.69 164.32,24.34 v1(164.32,25.23)
  BOTTOM w0.127: v1(164.32,25.23) 164.4,25.15 CN14.16
MY11: length 32.5
  TOP w0.127: v1(140.45,18.05) 140.45,17.33 140.28,17.16 U16.51
  IN1 w0.102: v1(166.1,20.43) 165.88,20.66 155.37,20.66 154.76,20.05 151.87,20.05 150.35,18.53 150.35,17.99 148.44,16.08 141.54,16.08 140.45,17.17 v1(140.45,18.05)
  BOTTOM w0.127: CN14.15 165.4,21.1 166.07,20.43 v1(166.1,20.43)
MY12: length 33.8
  TOP w0.127: v1(141.49,18.45) 140.91,17.87 140.91,17.84 140.88,17.81 140.88,17.36 140.68,17.16 U16.52
  IN1 w0.102: v1(141.49,18.45) 141.35,18.45 140.98,18.09 140.98,17.16 141.86,16.29 148.36,16.29 150.15,18.08 150.15,18.61 151.78,20.25 154.68,20.25 155.29,20.86 166.31,20.86 v1(166.74,20.43)
  BOTTOM w0.127: v1(166.74,20.43) 166.4,20.77 CN14.14
MY13: length 36.4
  TOP w0.127: U16.53 141.08,17.16 141.16,17.24 141.16,17.73 141.44,18.01 141.84,18.01 142.12,18.28 v1(142.12,18.83)
  IN1 w0.102: v1(167.73,20.44) 167.73,20.71 167.17,21.26 154.96,21.26 154.35,20.66 151.58,20.66 149.69,18.77 149.69,18.39 149.03,17.73 147.75,17.73 147.59,17.9 147.25,17.9 146.96,17.61 145.85,16.49 141.94,16.49 141.19,17.25 141.19,17.88 141.3,17.99 141.87,17.99 142.12,18.23 v1(142.12,18.83)
  BOTTOM w0.127: CN14.13 167.4,20.76 v1(167.73,20.44)
MY14: length 32.6
  TOP w0.127: v1(141.63,17.57) 141.63,17.34 141.48,17.2 U16.54
  IN1 w0.102: v1(141.63,17.57) 142.48,16.71 145.78,16.71 146.88,17.81 147.17,18.1 147.67,18.1 147.83,17.94 148.93,17.94 149.49,18.5 149.49,18.85 151.49,20.86 154.27,20.86 154.88,21.47 167.91,21.47 168.64,20.73 v1(168.64,20.53)
  BOTTOM w0.127: CN14.12 168.4,20.77 v1(168.64,20.53)
MY15: length 35.9
  TOP w0.127: v1(143.7,18.85) 143.48,18.85 142.54,17.91 142.54,17.83 141.88,17.16 U16.55
  IN1 w0.102: v1(169.4,20.53) 169.4,20.73 168.46,21.67 154.67,21.67 154.06,21.06 151.41,21.06 149.29,18.94 149.29,18.62 148.83,18.17 147.89,18.17 147.76,18.3 147.08,18.3 146.79,18.01 145.69,16.91 143.67,16.91 142.78,17.79 142.78,18.19 143.45,18.85 v1(143.7,18.85)
  BOTTOM w0.127: CN14.11 169.4,20.53 v1(169.4,20.53)
MY16: length 35.2
  TOP w0.127: v1(143.47,18.21) 143.27,18.01 143.13,18.01 142.28,17.16 U16.56
  IN1 w0.102: v1(143.47,18.21) 143.27,18.01 143.27,17.59 143.75,17.12 145.61,17.12 146.71,18.22 147,18.51 147.84,18.51 147.98,18.37 148.7,18.37 149.06,18.72 149.06,19 151.33,21.26 153.97,21.26 154.58,21.87 170.22,21.87 170.67,21.42 v1(170.67,20.53)
  BOTTOM w0.127: v1(170.67,20.53) 170.4,20.8 CN14.10
MY17: length 34.6
  TOP w0.127: v1(144.39,18.88) 144.18,18.67 144.18,18.27 143.39,17.48 143,17.48 142.68,17.16 U16.57
  IN1 w0.102: v1(171.4,20.53) 171.4,21.29 170.61,22.08 154.5,22.08 154.19,21.77 152.64,21.77 152.34,21.47 151.24,21.47 148.83,19.06 148.83,18.81 148.59,18.57 148.06,18.57 147.93,18.71 146.91,18.71 146.63,18.42 145.88,18.42 145.43,18.88 v1(144.39,18.88)
  BOTTOM w0.127: v1(171.4,20.53) CN14.9
NBSWON#: length 38.1
  TOP w0.203: U16.107 141.48,33.09 141.97,33.58 141.97,34.26 141.87,34.36 R212.1
  TOP w0.381: v1(141.19,33.69) 141.5,33.99 R212.1
  TOP w0.508: R253.2 154.52,24.86 155.02,25.35 C258.1 154.96,25.95 v1(154.96,26.71)
  IN1 w0.508: v1(156.82,30.36) 156.82,30.05 154.96,28.18 v1(154.96,26.71)
  IN2 w0.508: v1(141.19,33.69) 141.85,33.69 142.98,32.56 146.34,32.56 147.63,31.28 152.22,31.28 153.69,29.81 153.69,28.67 154.06,28.29 155.16,28.29 155.86,28.99 155.86,29.49 156.73,30.36 v1(156.82,30.36)
  BOTTOM w0.508: SW3.3 139.42,35.46 v1(141.19,33.69) 142.97,35.46 SW3.4
NGFF_SATA_DET#: length 86.7
  TOP w0.127: v1(89.06,99.77) R21.1 90.66,99.77 v1(90.74,99.69)
  TOP w0.14: v1(22.71,93.27) 23.14,93.71 R47.2 ; v1(90.74,99.69) 90.85,99.57 90.85,98.31 91.21,97.95 92.01,97.95 92.43,97.54 Q4.5
  IN1 w0.114: v1(90.74,99.69) 90.51,99.92 80.24,99.92 79.42,100.74 78.31,100.74 77.74,100.17 70.92,100.17 69.01,102.08 67.89,102.08 66.51,103.46 54.08,103.46 49.32,98.69 47.28,98.69 43.13,94.54 23.97,94.54 v1(22.71,93.27)
  BOTTOM w0.14: CN5.69 24.18,94.74 v1(22.71,93.27)
ODD_RXN: length 16.1
  BOTTOM w0.127: C427.2 130.65,23.94 129.94,23.94 129.5,24.38 129.5,25.26 127.77,26.98 124,26.98 122.68,28.3 122.68,30.14 122.13,30.68 121.97,30.84 121.01,30.84 120.54,31.31 120.23,31.31 120.06,31.14 U32.30
ODD_RXN_C: length 14.6
  BOTTOM w0.127: C427.1 131.78,23.93 132.1,23.93 132.91,23.12 132.91,22.46 134.23,21.14 134.23,19.15 134.59,18.79 136.18,18.79 136.31,18.66 141.05,18.66 141.35,18.95 141.35,19.2 141.45,19.31 CN16.5
ODD_RXP: length 16.1
  BOTTOM w0.127: U32.29 120.63,31.54 121.1,31.07 122.15,31.07 122.97,30.26 122.97,28.42 124.12,27.28 127.89,27.28 129.79,25.38 129.79,24.5 130.06,24.23 130.34,24.23 C424.2
ODD_RXP_C: length 14.6
  BOTTOM w0.127: C424.1 131.53,24.65 131.53,24.31 131.62,24.22 132.22,24.22 133.2,23.24 133.2,22.58 134.52,21.26 134.52,19.27 134.71,19.08 136.3,19.08 136.43,18.95 140.93,18.95 141.05,19.07 141.05,19.2 140.95,19.31 CN16.6
ODD_TXN: length 16.4
  BOTTOM w0.127: U32.32 120.08,30.34 120.1,30.32 121.59,30.32 122.03,29.88 122.03,28.03 123.79,26.27 127.55,26.27 128.85,24.97 128.85,23.83 130.22,22.46 130.49,22.46 C431.2
ODD_TXN_C: length 18.3
  BOTTOM w0.127: C431.1 131.61,22.4 131.71,22.3 132.12,22.3 133.55,20.87 133.55,18.57 134.22,17.9 134.22,16.89 134.44,16.67 141.41,16.67 142.58,17.84 142.58,19.18 142.45,19.31 CN16.3
ODD_TXP: length 16.5
  BOTTOM w0.127: U32.33 120.1,29.94 120.24,30.08 121.42,30.08 121.74,29.76 121.74,27.91 123.67,25.98 127.43,25.98 128.56,24.85 128.56,23.7 130.1,22.17 130.51,22.17 C437.2
ODD_TXP_C: length 18.4
  BOTTOM w0.127: CN16.2 142.95,19.3 142.87,19.23 142.87,17.71 141.53,16.37 134.32,16.37 133.92,16.77 133.92,17.78 133.26,18.45 133.26,20.75 132,22.01 131.78,22.01 C437.1
PANEL_LED_EN: length 324.2
  TOP w0.127: v1(51.43,130.86) v1(50.53,130.86)
  TOP w0.203: U16.78 148.13,23.26 v1(148.28,23.41)
  TOP w0.254: PR208.1 68.31,135.34 v1(67.68,135.97) ; v1(59.68,117.3) 59.68,117.29 PR207.1 ; PR7.1 v1(51.43,130.86)
  IN1 w0.254: v1(148.28,23.41) 146.99,23.41 146.25,22.67 141.48,22.67 140.69,21.88 135.85,21.88 135.6,21.62 135.6,21.09 135.32,20.81 134.81,20.81 134.05,21.57 131.86,21.57 128.45,24.98 123.69,24.98 122.99,24.29 122.41,24.29 119.56,21.44 119.56,16.46 118.56,15.46 84.82,15.46 81.85,12.49 38.48,12.49 37.12,13.85 37.12,15.74 36.6,16.26 36.6,16.71 30.72,22.59 28.82,22.59 18.64,32.77 18.64,32.78 18.39,33.02 18.39,52.27 18.64,52.51 18.64,68.82 16.9,70.57 16.9,75.91 18.34,77.36 18.34,81.74 17.77,82.32 17.77,82.76 15.58,84.94 15.07,84.94 13.96,86.06 13.96,86.31 12.09,88.18 12.09,90.6 21.91,100.42 37.58,100.42 40.52,103.36 40.52,105.16 42.51,107.14 42.51,110.29 v1(44.82,112.6) 45.2,112.22 46.48,112.22 48.53,114.27 48.53,116.9 49.75,118.12 49.75,127.59 51.43,129.27 v1(51.43,130.86)
  IN3 w0.254: v1(44.82,112.6) 45.33,112.6 45.61,112.32 50.65,112.32 52.31,110.66 56.22,110.66 59.68,114.11 v1(59.68,117.3) ; v1(51.43,130.86) 51.99,130.31 55.39,130.31 55.97,130.89 57.55,130.89 58.56,131.91 63.61,131.91 v1(67.68,135.97)
PCBEEP: length 4.5
  TOP w0.14: U15.12 198.57,24.4 198.28,24.11 198.28,22.46 v1(197.77,21.94) 196.48,21.94 C264.1
PCBEEP_EC: length 86.1
  TOP w0.127: U16.34 133.48,17.16 133.27,17.37 132.87,17.37 132.45,16.95 v1(132.45,16.72)
  IN3 w0.14: v1(132.45,16.72) 132.78,17.05 136.41,17.05 136.64,17.28 136.64,19.05 137.43,19.84 143.6,19.84 144.04,20.27 146.36,20.27 148.21,18.41 148.77,18.41 150.4,20.05 152.41,20.05 154.79,22.43 171.06,22.43 173.92,19.56 180.94,19.56 181.29,19.21 181.29,17.94 180.96,17.61 v1(180.71,17.61)
  BOTTOM w0.14: D23.2 195.96,29.32 195.35,29.93 192.9,29.93 191.59,28.61 191.59,27.74 191.47,27.62 190.29,27.62 189.24,26.57 189.24,26.22 188.83,25.81 185.69,25.81 184.44,24.56 184.44,23.3 185.55,22.19 185.55,19.45 183.81,17.71 180.81,17.71 v1(180.71,17.61)
PCH_BATLOW#: length 14
  TOP w0.14: v1(81.1,84.98) 81.04,84.98 80.23,84.17 80.23,83.88 79.36,83.02 78.63,83.02 77.94,82.33 75.92,82.33 74.51,83.74 72.36,83.74 v1(72.02,84.08) 71.68,83.74 70.26,83.74 R82.2
  BOTTOM w0.102: v1(81.1,84.98) 81.47,85.34 U21.AH51
PCH_BKLTCTL: length 9.5
  BOTTOM w0.102: U21.C46 83.71,97.48 83.88,97.65 83.88,97.84 84.01,97.96 84.01,98.62 82.14,100.49 82.14,102.72
  BOTTOM w0.14: Q28.5 81.16,104.09 81.36,104.29 82.02,104.29 82.14,104.17 82.14,102.72
PCH_BKLTEN: length 12.6
  BOTTOM w0.102: U21.B47 83.25,97.84 83.12,97.97 83.12,98.22 83.06,98.27 83.06,98.65 82.31,99.41 80.9,99.41 79.52,100.79 78.02,100.79 77.81,101 77.81,102.72 77.55,102.98
  BOTTOM w0.14: Q26.5 76.44,104.25 76.59,104.4 77.38,104.4 77.53,104.25 77.53,103 77.55,102.98
PCH_BLON: length 29.3
  TOP w0.14: R10.1 52.67,107.5 66.38,107.5 67.78,106.09 v1(70.91,106.09)
  BOTTOM w0.14: R332.1 76.05,102.36 75.79,102.62 Q26.6 75.79,104.44 75.08,105.15 75.08,106.4 73.96,107.52 72.01,107.52 70.91,106.41 v1(70.91,106.09)
PCH_BLON_EC: length 244.3
  TOP w0.14: v1(148.61,26.68) 148.03,27.26 U16.88 ; R9.1 50.54,106.08 48.75,104.29 47.05,104.29 46.47,103.71 v1(45.22,103.71)
  IN1 w0.102: v1(148.61,26.68) 147.81,25.89 147.81,24.91 146.05,23.15 141.28,23.15 140.5,22.37 135.99,22.37 135.32,23.04 131.6,23.04 129.18,25.46 123.44,25.46 122.77,24.79 122.21,24.79 119.06,21.64 119.06,16.66 118.36,15.96 84.61,15.96 81.62,12.97 38.71,12.97 37.62,14.06 37.62,15.94 37.1,16.47 37.1,16.91 30.94,23.07 29.32,23.07 v1(29.12,23.27)
  IN3 w0.127: v1(29.12,23.27) 24.12,28.27 24.12,32.73 25.03,33.65 25.03,38.3 23.9,39.43 23.9,41.17 23.69,41.38 23.69,56.57 23.61,56.65 23.61,70.16 24.99,71.54 24.99,71.55 25.47,72.03 25.47,74.97 24.99,75.46 24.99,78.13 26.14,79.28 26.14,85.74 26.78,86.38 26.78,89.98 29.77,92.96 34.83,92.96 38.47,96.61 42.55,96.61 45.22,99.28 v1(45.22,103.71)
PCH_BLON_R: length 5.8
  TOP w0.14: Q3.5 49.13,106.63 R9.2 R8.1 50.32,107.85 51.08,107.85 R10.2
PCH_BRIGHT: length 35.7
  IN1 w0.102: v1(61.86,122.92) 65.47,122.92 69.02,119.36 69.02,115.35 v1(71.98,112.4)
  BOTTOM w0.127: CN3.27 61.32,123.45 v1(61.86,122.92)
  BOTTOM w0.14: R337.1 80.22,102.49 80.51,102.77 Q28.6 80.51,103.89 79.74,104.66 79.74,106.56 79.84,106.66 79.84,107.84 79.15,108.54 73.19,108.54 71.98,109.75 v1(71.98,112.4)
PCH_MBCLK0_R: length 14.5
  BOTTOM w0.102: U21.T62 75.74,90.92 74.9,90.92
  BOTTOM w0.127: 74.9,90.92 72.12,93.71 70.38,93.71 70.05,94.04 69,94.04 68.4,94.63 67.9,94.63 67.45,95.08 66.08,95.08 65.88,94.88 Q29.6 65.88,94.02 65.66,93.8 R368.1 v1(65,94.68)
PCH_MBDAT0_R: length 16.3
  BOTTOM w0.102: 75.15,91.14 75.54,91.14 75.66,91.26 75.92,91.26 76.21,90.97 U21.T61
  BOTTOM w0.127: R365.1 66.29,97.77 66.74,97.77 67.18,97.32 Q29.3 67.18,95.66 67.36,95.49 67.78,95.49 67.93,95.34 v1(68.19,95.08) 68.69,95.08 69.3,94.47 70.35,94.47 70.76,94.06 72.23,94.06 75.15,91.14
PCH_SLP_SUS#: length 1.7
  TOP w0.14: U16.19 129.76,23.26 TP25.1
PCH_SPI_CLK: length 12.6
  BOTTOM w0.102: U21.C56 79.07,97.79 79.2,97.91 79.2,98.86 78.96,99.1 78.44,99.1 77.86,99.67 77.02,99.67 75.97,100.73
  BOTTOM w0.127: 75.97,100.73 73.19,100.73 v1(71.99,101.93) 70.59,103.33 R302.1
PCH_SPI_CLK_EC: length 19
  TOP w0.14: v1(139.62,42.85) 139.62,41.39 139.97,41.05 141.03,41.05 143.01,39.06 143.01,33.59 142.28,32.86 U16.105
  BOTTOM w0.14: U28.6 137.19,39.2 139.62,41.63 v1(139.62,42.85)
PCH_SPI_CS0#: length 38
  TOP w0.127: U1.1 71.89,126.67 71.59,126.37 70.95,126.37 69.71,125.13 v1(69.71,124.57)
  BOTTOM w0.102: 75.55,100.48 75.93,100.48 76.94,99.47 77.21,99.47 78.36,98.32 U21.B57
  BOTTOM w0.127: 75.55,100.48 72.72,100.48 v1(70.81,102.4) 70.41,102.8 R326.1 69.95,103.6 69.9,103.64 69.9,106.86 71.03,107.99 71.03,118.04 70.21,118.86 70.21,121.62 69.71,122.12 v1(69.71,124.57)
