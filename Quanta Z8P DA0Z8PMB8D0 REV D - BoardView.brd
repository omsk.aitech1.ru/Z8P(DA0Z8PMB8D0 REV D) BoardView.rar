# Allegro board Quanta Z8P DA0Z8PMB8D0 REV D - BoardView.brd (continued)
## Nets (continued)
M_B_DQ33: U21.BD10(DDR3L_CH1_DQ33_LPDDR3_CH1_DQB1) U27.C2(DQU3/DQ11)
M_B_DQ34: U21.BE14(DDR3L_CH1_DQ34_LPDDR3_CH1_DQB2) U27.D7(DQU0/DQ8)
M_B_DQ35: U21.BB10(DDR3L_CH1_DQ35_LPDDR3_CH1_DQB3) U27.A3(DQU7/DQ15)
M_B_DQ36: U21.BA14(DDR3L_CH1_DQ36_LPDDR3_CH1_DQB4) U27.C8(DQU2/DQ10)
M_B_DQ37: U21.BB14(DDR3L_CH1_DQ37_LPDDR3_CH1_DQB5) U27.B8(DQU6/DQ14)
M_B_DQ38: U21.BD14(DDR3L_CH1_DQ38_LPDDR3_CH1_DQB6) U27.A7(DQU4/DQ12)
M_B_DQ39: U21.BE8(DDR3L_CH1_DQ39_LPDDR3_CH1_DQB7) U27.C3(DQU1/DQ9)
M_B_DQ40: U11.H3(DQL4/DQ4) U21.AV12(DDR3L_CH1_DQ40_LPDDR3_CH1_DQB8)
M_B_DQ41: U11.F8(DQL3/DQ3) U21.BD6(DDR3L_CH1_DQ41_LPDDR3_CH1_DQB9)
M_B_DQ42: U11.F2(DQL2/DQ2) U21.BD5(DDR3L_CH1_DQ42_LPDDR3_CH1_DQB10)
M_B_DQ43: U11.F7(DQL1/DQ1) U21.BB7(DDR3L_CH1_DQ43_LPDDR3_CH1_DQB11)
M_B_DQ44: U11.H8(DQL5/DQ5) U21.AV10(DDR3L_CH1_DQ44_LPDDR3_CH1_DQB12)
M_B_DQ45: U11.H7(DQL7/DQ7) U21.AY9(DDR3L_CH1_DQ45_LPDDR3_CH1_DQB13)
M_B_DQ46: U11.G2(DQL6/DQ6) U21.AY7(DDR3L_CH1_DQ46_LPDDR3_CH1_DQB14)
M_B_DQ47: U11.E3(DQL0/DQ0) U21.BF5(DDR3L_CH1_DQ47_LPDDR3_CH1_DQB15)
M_B_DQ48: U21.AU2(DDR3L_CH1_DQ48_LPDDR3_CH1_DQB16) U27.F7(DQL1/DQ1)
M_B_DQ49: U21.AT10(DDR3L_CH1_DQ49_LPDDR3_CH1_DQB17) U27.H7(DQL7/DQ7)
M_B_DQ50: U21.AT9(DDR3L_CH1_DQ50_LPDDR3_CH1_DQB18) U27.H3(DQL4/DQ4)
M_B_DQ51: U21.AU1(DDR3L_CH1_DQ51_LPDDR3_CH1_DQB19) U27.F2(DQL2/DQ2)
M_B_DQ52: U21.AY5(DDR3L_CH1_DQ52_LPDDR3_CH1_DQB20) U27.F8(DQL3/DQ3)
M_B_DQ53: U21.AV5(DDR3L_CH1_DQ53_LPDDR3_CH1_DQB21) U27.E3(DQL0/DQ0)
M_B_DQ54: U21.AV6(DDR3L_CH1_DQ54_LPDDR3_CH1_DQB22) U27.G2(DQL6/DQ6)
M_B_DQ55: U21.AV7(DDR3L_CH1_DQ55_LPDDR3_CH1_DQB23) U27.H8(DQL5/DQ5)
M_B_DQ56: U11.D7(DQU0/DQ8) U21.AY2(DDR3L_CH1_DQ56_LPDDR3_CH1_DQB24)
M_B_DQ57: U11.A3(DQU7/DQ15) U21.BD2(DDR3L_CH1_DQ57_LPDDR3_CH1_DQB25)
M_B_DQ58: U11.C3(DQU1/DQ9) U21.BD1(DDR3L_CH1_DQ58_LPDDR3_CH1_DQB26)
M_B_DQ59: U11.A2(DQU5/DQ13) U21.BE2(DDR3L_CH1_DQ59_LPDDR3_CH1_DQB27)
M_B_DQ60: U11.C8(DQU2/DQ10) U21.AW1(DDR3L_CH1_DQ60_LPDDR3_CH1_DQB28)
M_B_DQ61: U11.B8(DQU6/DQ14) U21.AW2(DDR3L_CH1_DQ61_LPDDR3_CH1_DQB29)
M_B_DQ62: U11.A7(DQU4/DQ12) U21.AY3(DDR3L_CH1_DQ62_LPDDR3_CH1_DQB30)
M_B_DQ63: U11.C2(DQU3/DQ11) U21.BG2(DDR3L_CH1_DQ63_LPDDR3_CH1_DQB31)
M_B_DQS0: U21.BG28(DDR3L_CH1_DQSP0_LPDDR3_CH1_DQSP) U26.F3(DQSL)
M_B_DQS1: U10.F3(DQSL) U21.BD29(DDR3L_CH1_DQSP1_LPDDR3_CH1_DQSP)
M_B_DQS2: U21.BJ22(DDR3L_CH1_DQSP2_LPDDR3_CH1_DQSP) U26.C7(DQSU)
M_B_DQS3: U10.C7(DQSU) U21.AV25(DDR3L_CH1_DQSP3_LPDDR3_CH1_DQSP)
M_B_DQS4: U21.BB12(DDR3L_CH1_DQSP4_LPDDR3_CH1_DQSP) U27.C7(DQSU)
M_B_DQS5: U11.F3(DQSL) U21.BB5(DDR3L_CH1_DQSP5_LPDDR3_CH1_DQSP)
M_B_DQS6: U21.AT5(DDR3L_CH1_DQSP6_LPDDR3_CH1_DQSP) U27.F3(DQSL)
M_B_DQS7: U11.C7(DQSU) U21.BC2(DDR3L_CH1_DQSP7_LPDDR3_CH1_DQSP)
M_B_DQS#0: U21.BH29(DDR3L_CH1_DQSN0_LPDDR3_CH1_DQSN) U26.G3(D\Q\S\L\)
M_B_DQS#1: U10.G3(D\Q\S\L\) U21.BB29(DDR3L_CH1_DQSN1_LPDDR3_CH1_DQSN)
M_B_DQS#2: U21.BG22(DDR3L_CH1_DQSN2_LPDDR3_CH1_DQSN) U26.B7(D\Q\S\U\)
M_B_DQS#3: U10.B7(D\Q\S\U\) U21.AW25(DDR3L_CH1_DQSN3_LPDDR3_CH1_DQSN)
M_B_DQS#4: U21.BD12(DDR3L_CH1_DQSN4_LPDDR3_CH1_DQSN) U27.B7(D\Q\S\U\)
M_B_DQS#5: U11.G3(D\Q\S\L\) U21.BB6(DDR3L_CH1_DQSN5_LPDDR3_CH1_DQSN)
M_B_DQS#6: U21.AT6(DDR3L_CH1_DQSN6_LPDDR3_CH1_DQSN) U27.G3(D\Q\S\L\)
M_B_DQS#7: U11.B7(D\Q\S\U\) U21.BB1(DDR3L_CH1_DQSN7_LPDDR3_CH1_DQSN)
M_B_ODT0: R160.2 U10.K1(ODT) U11.K1(ODT) U26.K1(ODT) U27.K1(ODT)
M_B_RAS#: R435.2 U10.J3(R\A\S\) U11.J3(R\A\S\) U21.BJ6(DDR3L_CH1_RAS_N_LPDDR3_CH1_CAB3) U26.J3(R\A\S\) U27.J3(R\A\S\)
M_B_WE#: R441.2 U10.L3(W\E\) U11.L3(W\E\) U21.BH7(DDR3L_CH1_WE_N_LPDDR3_CH1_CAB4) U26.L3(W\E\) U27.L3(W\E\)
M_B_ZQ1: R413.2 U26.L8(ZQ)
M_B_ZQ2: R155.2 U10.L8(ZQ)
M_B_ZQ3: R159.2 U11.L8(ZQ)
M_B_ZQ4: R411.2 U27.L8(ZQ)
MA_DRAMRST#: C102.1 C103.1 R106.2 U8.T2(R\E\S\E\T\) U9.T2(R\E\S\E\T\) U21.AR34(DDR3L_CH0_RESET_N_LPDDR3_NC) U24.T2(R\E\S\E\T\) U25.T2(R\E\S\E\T\)
MAIND: PC31.1 PQ1.3(D) PQ4.2(G) PR35.2
MAINON: PQ2.2(BASE) PR38.1 PR138.1 PR142.1 PR174.1 PR182.1 PR193.1 R480.1 U16.30(PWM4/GPA4)
MAINON_ON_G: PQ1.2(G) PQ2.3(COLLECTOR) PQ3.2(G) PQ5.2(G) PQ15.2(G) PR36.2 PR37.1
MB_DRAMRST#: C97.1 C101.1 R105.2 U10.T2(R\E\S\E\T\) U11.T2(R\E\S\E\T\) U21.AR30(DDR3L_CH1_RESET_N_LPDDR3_NC) U26.T2(R\E\S\E\T\) U27.T2(R\E\S\E\T\)
MBCLK: PC56.1 PD5.1 PR74.2 PR76.1 R206.1 U16.110(SMCLK0/GPB3)
MBDATA: PC57.1 PD6.1 PR70.1 PR75.2 R211.1 U16.111(SMDAT0/GPB4)
MCSI_DPHY1.1_RCOMP: R44.1 U21.H27(MCSI_DPHY1.1_RCOMP)
MCSI_DPHY1.2_RCOMP: R40.1 U21.F27(MCSI_DPHY1.2_RCOMP)
MDI_0+: U13.1(MDIP0) U20.2(TD1+)
MDI_0-: U13.2(MDIN0) U20.3(TD1-)
MDI_1+: U13.4(MDIP1) U20.5(TD2+)
MDI_1-: U13.5(MDIN1) U20.6(TD2-)
MDI_2+: U13.6(MDIP2) U20.8(TD3+)
MDI_2-: U13.7(MDIN2) U20.9(TD3-)
MDI_3+: U13.9(MDIP3) U20.11(TD4+)
MDI_3-: U13.10(MDIN3) U20.12(TD4-)
MDSI_RCOMP: R87.1 U21.AP7(MDSI_RCOMP)
ME_WR#: Q30.2(G) U16.109(TXD/SOUT0/GPB1)
MEM_CH0_RCOMP: R89.1 U21.AV34(MEM_CH0_RCOMP)
MEM_CH1_RCOMP: R91.1 U21.AV30(MEM_CH1_RCOMP)
MIC2-VREFO: R477.1 R478.1 U15.29(MIC2-VREFO)
MX0: CN14.1 U16.58(KSI0/STB#)
MX1: CN14.2 U16.59(KSI1/AFD#)
MX2: CN14.3 U16.60(KSI2/INIT#)
MX3: CN14.4 U16.61(KSI3/SLIN#)
MX4: CN14.5 U16.62(KSI4)
MX5: CN14.6 U16.63(KSI5)
MX6: CN14.7 U16.64(KSI6)
MX7: CN14.8 U16.65(KSI7)
MY0: CN14.26 U16.36(KSO0/PD0)
MY1: CN14.25 U16.37(KSO1/PD1)
MY2: CN14.24 U16.38(KSO2/PD2)
MY3: CN14.23 U16.39(KSO3/PD3)
MY4: CN14.22 U16.40(KSO4/PD4)
MY5: CN14.21 U16.41(KSO5/PD5)
MY6: CN14.20 U16.42(KSO6/PD6)
MY7: CN14.19 U16.43(KSO7/PD7)
MY8: CN14.18 U16.44(KSO8/ACK#)
MY9: CN14.17 U16.45(KSO9/BUSY)
MY10: CN14.16 U16.46(KSO10/PE)
MY11: CN14.15 U16.51(KSO11/ERR#)
MY12: CN14.14 U16.52(KSO12/SLCT)
MY13: CN14.13 U16.53(KSO13)
MY14: CN14.12 U16.54(KSO14)
MY15: CN14.11 U16.55(KSO15)
MY16: CN14.10 U16.56(KSO16/SMOSI/GPC3(3))
MY17: CN14.9 U16.57(KSO17/SMISO/GPC5(3))
NBSWON#: C258.1 R212.1 R253.2 SW3.3 SW3.4 U16.107(PWRSW/GPE4)
NGFF_SATA_DET#: CN5.69 Q4.5(G) R21.1 R47.2
ODD_RXN: C427.2 U32.30(SRXN)
ODD_RXN_C: C427.1 CN16.5
ODD_RXP: C424.2 U32.29(SRXP)
ODD_RXP_C: C424.1 CN16.6
ODD_TXN: C431.2 U32.32(STXN)
ODD_TXN_C: C431.1 CN16.3
ODD_TXP: C437.2 U32.33(STXP)
ODD_TXP_C: C437.1 CN16.2
PANEL_LED_EN: PR7.1 PR207.1 PR208.1 U16.78(DAC2/TACH0B/GPJ2(3))
PCBEEP: C264.1 U15.12(PCBEEP)
PCBEEP_EC: D23.2(ANODE) U16.34(PWM7/RIG1#/GPA7)
PCH_BATLOW#: R82.2 U21.AH51(PMU_BATLOW_N)
PCH_BKLTCTL: Q28.5(G) U21.C46(PNL0_BKLTCTL)
PCH_BKLTEN: Q26.5(G) U21.B47(PNL0_BKLTEN)
PCH_BLON: Q26.6(D) R10.1 R332.1
PCH_BLON_EC: R9.1 U16.88(PS2DAT1/RTS0#/GPF3)
PCH_BLON_R: Q3.5(G) R8.1 R9.2 R10.2
PCH_BRIGHT: CN3.27 Q28.6(D) R337.1
PCH_MBCLK0_R: Q29.6(D) R368.1 U21.T62(SMB_CLK)
PCH_MBDAT0_R: Q29.3(D) R365.1 U21.T61(SMB_DATA)
PCH_SLP_SUS#: TP25.1 U16.19(L80HLAT/BAO/GPE0)
PCH_SPI_CLK: R302.1 U21.C56(FST_SPI_CLK)
PCH_SPI_CLK_EC: U16.105(FSCK/GPG7) U28.6(CLK)
PCH_SPI_CS0#: R326.1 U1.1(CE#) U21.B57(FST_SPI_CS0_N)
PCH_SPI_IO2: R352.1 U1.3(IO2) U21.B60(FST_SPI_IO2)
PCH_SPI_IO3: R354.1 U1.7(IO3) U21.B61(FST_SPI_IO3)
PCH_SPI_SI: U1.5(SI) U21.A58(FST_SPI_MOSI_IO0)
PCH_SPI_SI_EC: U16.102(FMOSI/GPG4) U28.5(SI)
PCH_SPI_SO: U1.2(SO) U21.B58(FST_SPI_MISO_IO1)
PCH_SPI_SO_EC: U16.103(FMISO/GPG5) U28.2(DO)
PCH_SUSPWRDNACK: R384.1 U16.15(ECSMI#/GPD4(3)) U21.AC63(SUSPWRDNACK)
PCH_TPD_INT#: Q20.6(D) R25.2 U21.J39(GPIO_18)
PCH_VDDEN: Q27.5(G) U21.C47(PNL0_VDDEN)
PCI_PLTRST#: C70.1 Q5.3(D) U21.AG57(PMU_PLTRST_N)
PCIE_CLKREQ_WLAN#: Q35.6(D) R392.2 R486.2 U21.AJ62(PCIE_CLKREQ3_N) U29.3(A)
PCIE_LAN_WAKE#: Q15.4(S) R366.1 U21.P61(PCIE_WAKE2_N)
PCIE_LAN_WAKE#_R: Q15.3(D) R168.2 U13.39(LANWAKEB)
PCIE_RCOMPN: R37.2 U21.F5(PCIE2_USB3_SATA3_RCOMP_N)
PCIE_RCOMPP: R37.1 U21.F6(PCIE2_USB3_SATA3_RCOMP_P)
PCIE_RX0+_SSD: R359.2 U21.P7(PCIE_P0_RXP)
PCIE_RX0-_SSD: R358.2 U21.P6(PCIE_P0_RXN)
PCIE_RX1+_SSD: R333.2 U21.T10(PCIE_P1_RXP)
PCIE_RX1+_SSD_R: CN5.31 R333.1
PCIE_RX1-_SSD: R351.2 U21.T12(PCIE_P1_RXN)
PCIE_RX1-_SSD_R: CN5.29 R351.1
PCIE_RX2+_LAN: C224.2 U21.M5(PCIE_P2_RXP)
PCIE_RX2+_LAN_C: C224.1 U13.25(HSOP)
PCIE_RX2-_LAN: C225.2 U21.M6(PCIE_P2_RXN)
PCIE_RX2-_LAN_C: C225.1 U13.26(HSON)
PCIE_RX3+_WLAN: CN9.41 U21.P12(PCIE_P3_USB3_P4_RXP)
PCIE_RX3-_WLAN: CN9.43 U21.P10(PCIE_P3_USB3_P4_RXN)
PCIE_TX0+_SSD: C324.2 U21.V3(PCIE_P0_TXP)
PCIE_TX0-_SSD: C323.2 U21.V2(PCIE_P0_TXN)
PCIE_TX1+_SSD: C312.2 U21.R1(PCIE_P1_TXP)
PCIE_TX1+_SSD_C: C312.1 CN5.37
PCIE_TX1-_SSD: C314.2 U21.R2(PCIE_P1_TXN)
PCIE_TX1-_SSD_C: C314.1 CN5.35
PCIE_TX2+: C335.1 U21.T2(PCIE_P2_TXP)
PCIE_TX2+_LAN: C335.2 U13.21(HSIP)
PCIE_TX2-: C334.1 U21.T3(PCIE_P2_TXN)
PCIE_TX2-_LAN: C334.2 U13.22(HSIN)
PCIE_TX3+: C332.1 U21.P3(PCIE_P3_USB3_P4_TXP)
PCIE_TX3+_WLAN: C332.2 CN9.35
PCIE_TX3-: C333.1 U21.P2(PCIE_P3_USB3_P4_TXN)
PCIE_TX3-_WLAN: C333.2 CN9.37
PCLK_TPM: R376.2 U14.19(LCLK/SCLK)
PD#: C219.1 D21.2(ANODE) D22.2(ANODE) R228.1 R232.2 U15.47(PDB)
PHASE_A: PC75.2 PL4.1 PQ13.1(S1) PQ13.2(S2) PQ13.3(S3) PQ14.5(D) PR5.1 PR121.2 PU4.8(PHASE)
PHASE_C: PC79.2 PL2.1 PQ11.1(S1) PQ11.2(S2) PQ11.3(S3) PQ12.5(D) PR16.1 PR91.2 PU3.8(PHASE)
PLTRST#: C212.1 C221.2 C425.1 CN5.50 CN9.52 D2.1(CATHODE) Q5.1(S) R66.2 U13.30(PERSTB) U14.17(L\R\E\S\E\T\/S\P\I\_\R\S\T\/S\R) U16.22(LPCRST#/GPD2)
PMU_RCOMP: R73.2 U21.AG59(PMU_RCOMP)
PMU_RSTBTN#: R389.1 TP36.1 U21.AD62(PMU_RSTBTN_N)
PMU_SLP_S0#: TP38.1 U21.AD61(PMU_SLP_S0_N)
PMU_SUSCLK: TP37.1 U21.AE62(PMU_SUSCLK)
PMU_WAKE#: R71.2 U21.AG55(PMU_WAKE_N)
PROCHOT_EC: Q17.2(G) R233.2 U16.17(LPCPD#/GPE6)
PWM_A: PR84.2 PR104.1
PWM_C: PR85.2 PR112.1
PWRLED#: CN17.8 U16.24(PWM0/GPA0)
R_SPK+: C435.1 CN19.1 U15.45(SPK-R+)
R_SPK-: C434.1 CN19.2 U15.44(SPK-R-)
RAM_ID0: R330.1 R350.2 U21.C31(GPIO_26)
RAM_ID1: R285.2 R293.1 U21.C29(GPIO_27)
RAM_ID2: R317.1 R340.2 U21.B37(GPIO_28)
RAM_ID3: R284.2 R292.1 U21.H35(GPIO_29)
RAM_ID4: R318.1 R338.2 U21.C37(GPIO_30)
RAM_ID5: R286.2 R294.1 U21.F34(GPIO_33)
REGOUT: C178.2 R174.1 U13.36(REGOUT)
RF_EN: CN9.56 R269.2
RING2: C441.2 CN17.27 CN17.28 CN17.29 D9.2 R477.2 U15.17(MIC2-L/RING2)
RSET: R173.2 U13.47(RSET)
RSMRST#: C449.1 R67.1 R210.1 U16.112(RING#/PWRFAIL#/CK32KOUT/LPCRST#) U21.AC57(RSM_RST_N)
RTC_RST#: C50.1 C253.1 J1.1 Q11.6(D) R245.2 U21.AC55(RTC_RST_N)
RTC_TEST#: C254.1 Q11.3(D) R246.2 U21.AH49(RTC_TEST_N)
RTC_X1: C47.2 R60.1 U21.AC59(RTC_X1) Y1.1
RTC_X2: C34.2 R60.2 U21.AC58(RTC_X2) Y1.2
S5_ON: PR136.2 PR170.2 PR172.2 R265.1 U16.69(ADC3/GPI3(3))
SATA_DEVSLP0: CN11.3 CN12.1 Q25.6(D) R289.1
SATA_DEVSLP1: CN5.38 Q24.6(D) R70.2 R300.1
SATA_RXN0: C193.1 U21.T7(SATA_P0_RXN)
SATA_RXN0_C: C193.2 U12.4(TX2N)
SATA_RXN0_CN: C191.1 CN12.16
SATA_RXN0_M2: C192.1 CN11.6
SATA_RXN0_RD: C191.2 C192.2 U12.12(RX2N)
SATA_RXN1: R362.2 U21.T6(SATA_P1_USB3_P5_RXN)
SATA_RXN1_R: CN5.43 R359.1 R362.1
SATA_RXP0: C197.1 U21.T9(SATA_P0_RXP)
SATA_RXP0_C: C197.2 U12.5(TX2P)
SATA_RXP0_CN: C199.1 CN12.15
SATA_RXP0_M2: C198.1 CN11.5
SATA_RXP0_RD: C198.2 C199.2 U12.11(RX2P)
SATA_RXP1: R361.2 U21.T5(SATA_P1_USB3_P5_RXP)
SATA_RXP1_R: CN5.41 R358.1 R361.1
SATA_TXN0: C185.1 U21.Y2(SATA_P0_TXN)
SATA_TXN0_C: C185.2 U12.2(RX1N)
SATA_TXN0_CN: C184.1 CN12.18
SATA_TXN0_M2: CN11.8 R203.2
SATA_TXN0_RD: C184.2 R203.1 U12.14(TX1N)
SATA_TXN1: C325.2 U21.W2(SATA_P1_USB3_P5_TXN)
SATA_TXN1_C: C323.1 C325.1 CN5.47
SATA_TXP0: C183.1 U21.Y3(SATA_P0_TXP)
SATA_TXP0_C: C183.2 U12.1(RX1P)
SATA_TXP0_CN: C181.1 CN12.19
SATA_TXP0_M2: CN11.9 R175.2
SATA_TXP0_RD: C181.2 R175.1 U12.15(TX1P)
SATA_TXP1: C326.2 U21.W1(SATA_P1_USB3_P5_TXP)
SATA_TXP1_C: C324.1 C326.1 CN5.49
SB_ACDC: PR57.1 R88.1 U16.84(EGCLK/GPE3)
SD_CLK_R: CN2.5(CLK) R247.1
SENSEA: R256.1 R257.1 U15.13(HP/LINE1 JD)
SIO_EXT_SCI#: R308.2 U16.23(ECSCI#/GPD3) U21.C34(GPIO_11)
SLEEVE: C442.2 CN17.24 CN17.25 CN17.26 D10.2 R478.2 U15.18(MIC2-R/SLEEVE)
SLP_S0IX#: TP15.1 U16.117(PECI/SMCLK2/GPF6(3))
SOC_OVRIDE: Q30.3(D) R381.2 U21.F62(SIO_SPI_2_CLK)
SOC_SERIRQ: R386.2 U14.27(SERIRQ) U22.4(B)
SOC_SERIRQ_R: R386.1 U21.AB62(LPC_SERIRQ)
SP1=SD_D1: C232.1 CN2.8(DAT1) U13.14(SD_D1)
SP2=SD_D0=MS_D1: C238.1 CN2.7(DAT0) U13.15(SD_D0/MS_D1)
SP3=SD_CLK=MS_D0: C246.1 R247.2 U13.16(SD_CLK/MS_D0)
SP4=SD_CMD=MS_D2: C445.1 CN2.2(CMD) U13.17(SD_CMD/MS_D2)
SP5=SD_D3=MS_D3: C446.1 CN2.1(CD/DAT3) U13.18(SD_D3/MS_D3)
SP6=SD_D2=MS_CLK: C447.1 CN2.9(DAT2) U13.19(SD_D2/MS_CLK)
SP7=SD_WP=MS_BS: CN2.11(WP) U13.28(SD_WP/MS_BS)
SP8=SD_CD#: CN2.10(CD) U13.42(SD_CD#)
SPI_CLK: U31.6(CLK) U32.3(I2C_CLK)
SPI_CLK_A: R302.2 U1.6(SCLK)
SPI_CS0: U31.1(C\S\) U32.6(GPIO4)
SPI_CS0#_UR_ME: R415.2 U16.101(FSCE#/GPG3) U28.1(C\S\)
SPI_DI: U31.2(DO) U32.2(I2C_DATA)
SPI_DO: U31.5(DI) U32.5(GPIO5)
SPI_HOLD#: R417.1 U28.7(H\O\L\D\)
SPI_WP#: R445.1 U28.3(W\P\)
SPIVCC_ON: R213.1 U16.100(SSCE0#/GPG2) U30.3(EN)
SPKR: D25.2(ANODE) U21.AK57(ISH_GPIO_9)
SUSB#: U16.119(DSR0#/GPG6) U21.AC62(PMU_SLP_S3_N)
SUSC#: U16.18(RI1#/GPD0(3)) U21.AK54(PMU_SLP_S4_N)
SUSLED#: CN17.9 U16.28(PWM2/GPA2)
SUSON: PR59.1 R215.1 U16.120(TMRI0/GPC4(3))
SVID_ALERT#_R: R329.2 U21.B17(SVID0_ALERT_N)
SY8286BBST: PR102.2 PU5.1(BS)
SY8286BBST_S: PC88.2 PR102.1
SY8286BEN: PC2.1 PR4.1 PU5.12(EN1)
SY8286BFB: PR99.2 PU5.13(FF)
SY8286BLDO: PC85.1 PR15.1 PR109.1 PU5.17(LDO)
SY8286BPG: PR3.1 PR87.1 PR88.2 PU5.9(PG)
SY8286BSW: PC88.1 PL3.1 PR17.1 PU5.6(LX#1) PU5.19(LX#2) PU5.20(LX#3)
SY8286BVOUT: PC84.2 PR125.2 PU5.14(OUT)
SY8288CBST: PR169.2 PU11.1(BS)
SY8288CBST_S: PC164.2 PR169.1
SY8288CEN: PC32.1 PR164.1 PU11.12(EN1)
SY8288CFB: PR168.2 PU11.13(FF)
SY8288CPG: PR157.1 PU11.9(PG)
SY8288CSW: PC164.1 PL8.1 PR40.1 PU11.6(LX#1) PU11.19(LX#2) PU11.20(LX#3)
SY8288CVOUT: PC34.2 PR171.2 PU11.14(OUT)
SYS_HWPG: PR87.2 PR157.2 U16.77(GPJ1(3))
SYS_SHDN#: PR4.2 PR109.2 PR156.2 PR164.2 R237.2
SYS_SHDN#_R: R237.1 U16.2(GPJ7)
TEMP_MBAT#: PR73.2 PR79.1 U16.73(ADC7/CTS1#/GPI7(3))
TERM9: C307.1 R12.2 R13.2 R14.2 R15.2
THERMTRIP#: R24.2 U16.122(DTR1#/SBUSY/GPG1/ID7)
THERMTRIP#_SOC: R23.1 R24.1 U21.J47(PMIC_THERMTRIP_N)
TP_PWR: C283.2 C284.2 CN3.30 CN3.31 R277.2
TPCLK: CN15.2 D28.2 R259.1 U16.89(PS2CLK2/GPF4)
TPD_EN: CN15.8 ESD4.4 R214.2
TPD_INT#: CN15.7 ESD4.3 Q20.5(G) R208.2 R261.1
TPDATA: CN15.3 D27.2 R258.1 U16.90(PS2DAT2/GPF5)
TPM_BADD: R221.2 U14.6(GPIO3/BADD)
TPM_PP: TP16.1 U14.4(PP)
TS_EN: CN3.28 R250.1
TS_EN_C: C256.1 R250.2 U16.81(DAC5/RIG0#/GPJ5(3))
TYPEC_CHG: R51.2 U3.7(CHG)
TYPEC_CHG_HI: R49.1 R50.2 U3.8(CHG_HI)
TYPEC_HPD#: R78.1 U21.A50(GPIO_199)
USB3_0_RXN: C170.2 L3.3 R167.2 U21.K10(USB3_P0_RXN)
USB3_0_RXN_R: CN8.5(STDA_SSRX-) ESD3.6(I/O-4) L3.4 R167.1
USB3_0_RXP: C169.2 L3.2 R165.2 U21.K9(USB3_P0_RXP)
USB3_0_RXP_R: CN8.6(STDA_SSRX+) ESD3.5(I/O-3) L3.1 R165.1
USB3_0_TXN: C159.1 U21.J2(USB3_P0_TXN)
USB3_0_TXN_C: C159.2 L1.3 R157.2
USB3_0_TXN_R: C161.1 CN8.8(STDA_SSTX-) ESD3.10(I/O-6) L1.4 R157.1
USB3_0_TXP: C154.1 U21.J1(USB3_P0_TXP)
USB3_0_TXP_C: C154.2 L1.2 R153.2
USB3_0_TXP_R: C155.1 CN8.9(STDA_SSTX+) ESD3.1(I/O-1) L1.1 R153.1
USB3_1_RXN: CN1.B10(SSRXN1) ESD2.2(LINE-3) U21.G2(USB3_P1_RXN)
USB3_1_RXP: CN1.B11(SSRXP1) ESD2.8(LINE-4) U21.F2(USB3_P1_RXP)
USB3_1_TXN: C36.1 U21.K2(USB3_P1_TXN)
USB3_1_TXN_CN: C36.2 CN1.A3(SSTXN1) ESD2.9(LINE-2)
USB3_1_TXP: C28.1 U21.K3(USB3_P1_TXP)
USB3_1_TXP_CN: C28.2 CN1.A2(SSTXP1) ESD2.1(LINE-1)
USB3_2_RXN: CN1.A10(SSRXN2) ESD2.5(LINE-8) U21.M7(PCIE_P5_USB3_P2_RXN)
USB3_2_RXP: CN1.A11(SSRXP2) ESD2.6(LINE-7) U21.K7(PCIE_P5_USB3_P2_RXP)
USB3_2_TXN: C51.1 U21.L1(PCIE_P5_USB3_P2_TXN)
USB3_2_TXN_CN: C51.2 CN1.B3(SSTXN2) ESD2.7(LINE-5)
USB3_2_TXP: C55.1 U21.L2(PCIE_P5_USB3_P2_TXP)
USB3_2_TXP_CN: C55.2 CN1.B2(SSTXP2) ESD2.4(LINE-6)
USB_OC0#: R68.1 R327.1 U21.B55(USB2_OC0_N)
USB_OC1#: R328.1 U7.3(OCB) U18.3(OCB) U21.C55(USB2_OC1_N)
USB_OTG_ID: R377.1 R382.1 U21.AC15(USB2_OTG_ID)
USB_SSIC_RCOMP: R64.1 U21.AB15(USB_SSIC_RCOMP)
USBCOMP: R75.1 U21.Y15(USB2_RCOMP)
USBON#: U7.4(EN) U16.99(ID6/GPH6) U18.4(EN)
USBP0+: L2.3 R161.2 U21.V12(USB2_DP0)
USBP0+_R: CN8.3(D+) ESD3.7(I/O-5) L2.4 R161.1
USBP0-: L2.2 R158.2 U21.V10(USB2_DN0)
USBP0-_R: CN8.2(D-) ESD3.4(I/O-2) L2.1 R158.1
USBP1+: CN1.A6(DP1) CN1.B6(DP2) ESD1.1 U21.V16(USB2_DP1)
USBP1-: CN1.A7(DN1) CN1.B7(DN2) ESD1.6 U21.V15(USB2_DN1)
USBP2+: L7.2 R272.2 U21.Y13(USB2_DP2)
USBP2+_R: CN17.18 ESD5.4 L7.1 R272.1
USBP2-: L7.3 R273.2 U21.V13(USB2_DN2)
USBP2-_R: CN17.19 ESD5.3 L7.4 R273.1
USBP3+: L6.2 R270.2 U21.V9(USB2_DP3)
USBP3+_R: CN17.14 ESD5.1 L6.1 R270.1
USBP3-: L6.3 R271.2 U21.V7(USB2_DN3)
USBP3-_R: CN17.15 ESD5.6 L6.4 R271.1
USBP4+: CN9.3 U21.Y9(USB2_DP4)
USBP4-: CN9.5 U21.Y10(USB2_DN4)
USBP5+: CN3.5 U21.AB6(USB2_DP5)
USBP5-: CN3.4 U21.AB7(USB2_DN5)
USBP6+: CN3.8 D11.2 U21.AC12(USB2_DP6)
USBP6-: CN3.7 D12.2 U21.AC10(USB2_DN6)
USBP7+: U21.V5(USB2_DP7) U32.15(UDP)
USBP7-: U21.V6(USB2_DN7) U32.16(UDM)
USBPWR1: C144.2 C145.2 C359.2 C370.2 CN8.1(VBUS) ESD3.2(VDD) U7.1(OUT)
USBPWR2: C271.2 C274.2 C275.2 CN17.1 CN17.2 CN17.3 CN17.4 CN17.5 ESD5.5(VDD) U18.1(OUT)
VA1: PC37.2 PC38.2 PC55.2 PC190.1 PD2.1 PD4.2(ANODE) PJ1.3 PJ1.4 PJ2.4 PJ2.5 PJ2.6 PQ6.1(S1) PQ6.2(S2) PQ6.3(S3) PQ16.3(PNP#C) PR187.1
VA2: PD3.1 PD3.2 PQ6.5(D)
VDD33/18: C226.1 C227.2 U13.27(VDD33/18)
VL: PC162.1 PR159.1 PU11.15(LDO)
VNN_ON: PR33.2 U16.76(TACH2/GPJ0(3))
VNN_SENSE: PR12.1 U21.AG48(VNN_SENSE)
VOUT_BACKLIGHT: C2.2 C9.1 CN3.39 CN3.40 R5.2 R6.2
VR_SVID_ALERT#_VCORE: PU6.36(ALERT#) R324.2 R329.1
VSTBY_FSPI: C5.1 C380.1 R205.1 R326.2 R352.2 R354.2 R415.1 R417.2 R445.2 R448.2 U1.8(VCC) U28.8(VCC)
VSTBY_FSPI_R: C206.1 R205.2 U16.106(VSTBY_FSPI)
WRST#: C416.1 D24.2(ANODE) Q33.6(D) R462.1 U16.14(WRST#)
XDP_PRDY#: R306.1 U21.C21(JTAG_PRDY_N)
XDP_PREQ#: R307.1 U21.C20(JTAG_PREQ_N)
XDP_TCK: R335.1 U21.B23(JTAG_TCK)
XDP_TDI: R305.1 U21.C22(JTAG_TDI)
XDP_TDO: R304.1 U21.A22(JTAG_TDO)
XDP_TMS: R303.1 U21.C23(JTAG_TMS)
XDP_TRST#: R322.1 U21.C24(JTAG_TRST_N)
XTAL192_IN: C310.2 R301.2 U21.R27(OSCIN) Y3.1
XTAL192_OUT: C309.2 R301.1 U21.P29(OSCOUT) Y3.3
N16788300: C252.1 U16.12(VCORE)
N16788484: C276.2 R269.1 U16.66(ADC0/GPI0(3))
N16788623: C194.1 R214.1 U16.98(ID5/GPH5)
N16789334: TP17.1 U16.126(GA20/GPB5(3))
N17002655: C223.2 U15.39(LDO2-CAP)
N17002661: C231.1 U15.37(CBP)
N17002676: C237.2 U15.34(CPVEE)
N17002678: C443.1 U15.19(MIC-CAP)
N17002722: TP19.1 U15.48(SPDIF-OUT)
N17002952: C250.1 U15.7(LDO3-CAP)
N17003087: D23.1(CATHODE) D25.1(CATHODE) R255.2
N17003129: C231.2 U15.35(CBN)
N17004316: D21.1(CATHODE) Q32.3(D)
N17045098: C207.1 R208.1 U16.128(GPJ6)
N19171544: C195.1 D6.2 R204.1 U16.118(SMDAT2/PECIRQT#/GPF7(3))
N19520551: CN14.27 R253.1
N20280006: PQ5.3(D) PR42.2
N20280012: PQ15.3(D) PR43.2
N22098686: Q27.2(G) Q27.3(D) R297.1
N22098968: Q26.2(G) Q26.3(D) R299.1
N22122752: Q13.3(D) R122.2 R126.2 R129.2 R133.2 R134.2 R138.2 R139.2 R143.2
N22131520: C138.1 Q14.2(VCC) R151.1
N22234733: C58.1 U21.AG51(VCC_RTC_EXTPAD)
N22534967: TP1.1 U21.J41(LPSS_UART2_RXD)
N22534977: TP2.1 U21.M41(LPSS_UART2_CTS_N)
N22543099: TP9.1 U21.AM51(ISH_GPIO_4)
N22543112: TP7.1 U21.AM49(ISH_GPIO_5)
N22543128: TP8.1 U21.AM57(ISH_GPIO_6)
N22543144: TP10.1 U21.AM55(ISH_GPIO_7)
N22563616: Q20.2(G) Q20.3(D) R267.1
N22799421: TP28.1 U16.48(TACH1A/TMA1/GPD7(3))
N22836684: PC148.1 PR148.2
N22836710: JP5.1 PC143.1 PC147.1 PL5.2 PR146.1
N22836724: JP6.2 PC144.1 PC149.1 PR147.1 PU8.9(VIN#1) PU8.10(VIN#2)
N22839470: PR33.1 PR131.2 PR133.2
N22839532: PC15.2 PC19.2 PC98.1 PR26.2 PR30.2 PR124.2
N22839622: PC15.1 PR23.2
N22839806: PC96.1 PR120.2
N22839827: PC94.1 PR118.2
N22841416: JP3.1 PC70.2 PC71.2 PC72.1 PC73.1 PQ13.5(D)
N22841457: PC1.1 PR5.2
N22841539: JP2.1 PC74.1 PC76.1 PC77.2 PC78.2 PQ11.5(D)
N22841632: PR84.1 PU4.3(PWM)
N22841634: PC67.2 PR1.2 PU4.6(VCC)
N22860674: PR6.1 PR110.1
N22860692: PC87.1 PR101.1
N22861223: PC3.2 PC4.1 PC83.2 PR12.2 PR13.2 PR95.2
N22861277: PC83.1 PR107.2
N22861281: PR97.1 TP29.1
N22861301: PC82.1 PR106.2
N22861313: PC81.1 PR105.2
N22885414: PR132.1 PU6.8(ISUMN_B)
N22946208: PC75.1 PR86.2
N22946214: PR86.1 PU4.2(BOOT)
N22946324: PQ13.4(G) PU4.1(UGATE)
N22949643: PC66.2 PR2.2 PU3.6(VCC)
N22949653: PR85.1 PU3.3(PWM)
N22950763: PC14.1 PR16.2
N22950767: PC79.1 PR92.2
N22950773: PR92.1 PU3.2(BOOT)
N22950844: PQ11.4(G) PU3.1(UGATE)
N22956619: PQ3.3(D) PR39.2
N23041304: TP6.1 U21.AG58(SUS_STAT_N)
N23063584: PC27.1 PC28.1 PC29.1 PL1.1 PQ22.3(D) PR28.1 PR29.2 PU1.8(IN)
N23063683: PC8.2 PR10.1
N23086343: TP32.1 U21.A26(GPIO_22)
N23103470: C190.2 C196.2 C201.1 C217.1 C222.1 C234.1 R236.1 U14.1(VSB) U14.8(VDD1) U14.14(VHIO#1) U14.22(VHIO#2)
N23135271: Q31.3(D) SW2.3 SW2.4
N23202325: R454.1 R455.1 R457.1
N23202350: C402.2 Q33.2(G) Q33.3(D) R457.2
N23458866: TP14.1 U13.37(LED3)
N23458888: TP13.1 U13.40(LED_CR)
N23458910: TP40.1 U13.43(MS_CD#)
N23458912: TP12.1 U13.38(LED1/GPO)
N25137104: R391.2 U21.AH62(PCIE_CLKREQ1_N)
N25421357: PC190.2 PQ6.4(G) PQ16.4(PNP#E) PR187.2 PR188.1
N25421372: PQ17.4(G) PR49.2 PR51.1
N25421377: PQ16.1(NPN#E) PQ16.2(PNP#B)
N25421382: PQ7.2(G) PQ16.5(NPN#B) PR189.1
N25421386: PL10.2 PR78.1 PR83.1
N25421433: PC52.1 PR69.2
N25421444: PJ5.3 PR75.1
N25421470: PD3.3 PR44.1 PR46.2
N25421477: PJ5.4 PR74.1
N25421489: PC54.2 PD7.1(CATHODE) PR72.2
N25421528: PD4.1(CATHODE) PR67.1 PR71.1
N25421533: PR58.1 PR71.2
N25421535: PR70.2 PU2.8(SDA)
N25421536: PR76.2 PU2.9(SCL)
N25421576: PR202.2 PU2.13(SRP)
N25421577: PR203.2 PU2.12(SRN)
N25421591: PQ7.3(D) PR51.2
N25421602: PQ10.3(D) PR201.1
N25421607: PQ9.2(G) PQ9.5(G) PR60.1 PU2.5(A\C\O\K\)
N25421616: PQ9.6(D) PR56.1 PR57.2
N25421661: PJ5.5 PR73.1
N26224666: Q28.2(G) Q28.3(D) R298.1
N26800092: TP26.1 U16.71(ADC5/DCD1#/GPI5(3))
N26800651: Q4.2(G) Q4.3(D) R22.1
N26801737: TP18.1 U16.94(CRX1/SIN1/SMCLK3/GPH1/ID1)
N26804054: CN5.10 TP35.1
N26804339: CN5.56 TP34.1
N26804367: CN5.58 TP33.1
N26947276: C420.2 R467.1
N27049263: Q19.2(G) Q19.3(D) R231.2
N27146970: R418.2 U29.5(EO)
N27714931: C10.2 U20.1(TCT1) U20.4(TCT2) U20.7(TCT3) U20.10(TCT4)
N27777984: Q22.2(G) Q23.3(COLLECTOR) R266.2
N27809336: R117.1 U6.4(REXT)
N27870072: PQ14.4(G) PU4.5(LGATE)
N27870812: PR90.1 PU4.7(FCCM)
N27871233: PQ12.4(G) PU3.5(LGATE)
N27872424: PR89.1 PU3.7(FCCM)
N27955093: PR31.1 PR32.2 PR113.2
N27955466: PR22.1 PR116.1
N27955489: PC91.1 PR115.1
N27962012: Q34.2(BASE) R468.2 R469.1
N28117117: R456.1 U32.10(VBUS)
N28117387: R458.1 U32.8(GPIO3)
N28123043: R449.1 U32.17(REXT)
N28127372: R471.2 U32.35(GPIO7)
N28131147: TP41.1 U32.41(UART_TX)
N28131150: TP42.1 U32.40(UART_RX)
N28131472: C426.1 R472.2 U32.38(RST#)
N28146944: R470.2 U32.37(GPIO6)
N28189975: R93.2 U4.5(EO)
N28192386: CN3.37 R274.2
N28293994: Q16.2(BASE) R222.2
N28332391: TP24.1 U16.16(PWUREQ#/BBO/SMCLK2ALT/GPC7(3))
N28332543: TP43.1 U16.35(RTS1#/GPE5)
N28332839: TP27.1 U16.70(ADC4/GPI4(3))
N28333200: TP22.1 U16.87(PS2CLK1/DTR0#/GPF2)
N28333244: TP21.1 U16.85(PS2CLK0/CEC/TMB0/GPF0)
N28653201: CN1.B8(SBU2) TP3.1
N28712721: CN1.A8(SBU1) TP4.1
N28748831: C70.2 R72.1
N28749147: C79.2 R83.1
N28749381: C50.2 R61.1
N28749503: C97.2 R101.1
N28749588: C102.2 R102.1
N28852170: R390.2 U22.5(EO)
N28853874: TP11.1 U13.41(LED0)
N29269526: PQ24.2(BASE) PR208.2 PR212.1
N29269540: PQ25.3(D) PR210.2
N29269542: PQ24.3(COLLECTOR) PQ25.2(G) PR209.2 PR211.1
N29271135: PC216.2 PQ22.2(G) PR205.2 PR206.1
N29271139: PC216.1 PQ22.1(S) PR204.2 PR205.1
N29271214: PQ23.3(D) PR206.2
N29271227: PQ23.2(G) PR207.2
N29632396: Q25.2(G) Q25.3(D) R487.1
N29634628: Q24.2(G) Q24.3(D) R488.1
N29639135: Q35.2(G) Q35.3(D) R489.1
N29643478: Q36.2(G) Q36.3(D) R490.1
N30017457: C449.2 R493.1
N30954436: PC186.1 PR181.1 PR183.1 PU14.6(VO)
N30954444: PR183.2 PR185.1 PU14.7(ADJ)
N31161143: PC174.1 PR173.1 PU13.4(VBIAS)
N31161147: PC183.1 PU13.12(CT1)
N31161149: PC184.1 PU13.10(CT2)
N31161190: PC175.1 PR174.2 PU13.5(ON2)
N31161198: PC176.1 PR172.1 PU13.3(ON1)
N31161958: PC120.1 PR137.1 PU7.4(VBIAS)
N31161974: PC119.1 PU7.12(CT1)
N31161976: PC124.1 PU7.10(CT2)
N31162017: PC125.1 PR138.2 PU7.5(ON2)
N31162025: PC117.1 PR136.1 PU7.3(ON1)
N32459164: PC207.2 PR195.1
N32459172: PC195.1 PR48.2 PU15.4(VTTREF)
N32459334: PR47.1 PU15.3(GND)
N32459384: PC40.1 PR52.2
N32810872: PC84.1 PR99.1
N32810957: PR93.2 PR98.1 PU5.11(EN2)
N32810977: PC13.1 PR17.2
N32811094: PC34.1 PR168.1
N32811135: PC163.2 PU11.17(VCC)
N32811186: PR158.2 PR162.1 PU11.11(EN2)
N32811216: PC33.1 PR40.2
N33973281: PR153.1 PU9.1(SET)
N33973285: PC160.1 PR159.2 PU9.5(VCC)
N33973296: PR156.1 PU9.3(O\T\)
N35788414: PC187.1 PC188.1 PR180.2 PU14.3(VIN)
N35788542: PC185.1 PR179.1 PU14.4(VPP)
N35790435: PC189.1 PR182.2 PR184.1 PU14.2(VEN)
N36056010: JP11.1 PC35.1 PC36.1 PC166.1 PL7.2 PR161.1
N36056030: PR166.2 PR167.1 PU12.6(VFB)
N36056032: PC161.1 PR41.2 PU12.4(VIN)
N36056052: PR161.2 PR166.1
N36056070: PC167.1 PR170.1 PU12.1(EN)
N36056085: PR165.1 PU12.5(PG)
N36057265: JP12.1 PC153.1 PC156.1 PC159.1 PL6.2 PR151.1
N36057275: PR154.2 PR155.1 PU10.6(VFB)
N36057285: PC150.1 PR150.2 PU10.4(VIN)
N36057305: PR151.2 PR154.1
N36057323: PC158.1 PR163.1 PU10.1(EN)
N36057338: PR152.1 PU10.5(PG)

Pads without a net: CN3 38; CN5 5 6 7 8 11 13 17 19 20 22 23 24 25 26 28 30 32 34 36 40 42 44 46 48 54 67 68; CN6 13 14; CN9 6 8 9 10 11 12 13 14 15 16 17 19 20 21 22 23 32 34 36 38 40 42 44 46 48 50 55 58 59 60 61 62 65 67; CN12 2 7 11 12; CN16 8 16; CN17 6; CN18 3; NOREF 1; NOREF#2 1; NOREF#7 1; NOREF#8 1; NOREF#9 1; NOREF#11 1; PU5 10 15 16; PU6 2 3 4 5 6 7 9 10 11 12 13; PU11 10 16; PU14 5; U2 A4 A6 A9 A11 AA1 AA2 AA7 AA8 AA9 AA10 AA11 AA12 AA13 AA14 AE1 AE14 AG2 AG13 AH4 AH6 AH9 AH11 B2 B13 D1 D14 H1 H2 H6 H7 H8 H9 H10 H11 H12 H13 H14 J1 J7 J8 J9 J10 J11 J12 J13 J14 K1 K3 K5 K7 K8 K9 K10 K11 K12 K13 K14 L1 L2 L3 L4 L12 L13 L14 M1 M2 M3 M5 M8 M9 M10 M12 M13 M14 N1 N2 N3 N10 N12 N13 N14 P1 P2 P3 P10 P12 P13 P14 R1 R2 R3 R12 R13 R14 T1 T2 T3 T5 T12 T13 T14 U1 U2 U3 U6 U7 U10 U12 U13 U14 V1 V2 V3 V12 V13 V14 W1 W2 W3 W7 W8 W9 W10 W11 W12 W13 W14 Y1 Y3 Y6 Y7 Y8 Y9 Y10 Y11 Y12 Y13 Y14; U6 3 23 24; U8 J1 J9 L1 L9; U9 J1 J9 L1 L9; U10 J1 J9 L1 L9; U11 J1 J9 L1 L9; U14 2 3 5 7 10 11 12 25 26 28 29 30 31; U15 14 15 16 23 24; U16 20 31 68 96 125; U17 2 3; U21 A3 A4 A10 A14 A18 A54 A60 A61 AB2 AB3 AB13 AB49 AB51 AB54 AB55 AB58 AC1 AC2 AC13 AC20 AC22 AC48 AC49 AC51 AC52 AD2 AD3 AE60 AF2 AF3 AF61 AF62 AG15 AG16 AG52 AG54 AG62 AG63 AH12 AH13 AJ44 AK6 AK7 AK13 AK15 AK16 AK61 AL62 AL63 AM5 AM6 AM7 AM9 AM10 AM12 AM13 AM15 AM16 AM32 AM52 AM58 AM59 AM61 AM62 AN32 AN62 AP2 AP3 AP5 AP6 AP10 AP12 AP13 AP15 AP49 AP51 AP57 AP58 AP59 AP61 AP62 AR1 AR2 AR21 AR29 AR35 AR62 AR63 AT21 AT30 AT34 AT43 AV16 AV17 AV47 AV48 AW16 AW17 AW19 AW21 AW23 AW41 AW43 AW45 AW47 AW48 B4 B13 B15 B19 B21 B27 B51 B53 BA19 BA23 BA41 BA45 BB17 BB21 BB23 BB41 BB43 BB47 BB48 BD21 BD23 BD43 BD47 BD48 BE23 BG1 BG17 BG63 BH17 BH58 BH60 BJ2 BJ3 BJ16 BJ58 BJ61 BJ62 C1 C2 C9 C10 C13 C14 C15 C19 C26 C30 C33 C35 C36 C38 C42 C43 C44 C45 C51 C52 C53 C54 C57 C62 C63 D1 D2 D4 D8 D61 E3 E6 E8 E10 E16 E17 E23 E25 E30 E39 E41 E52 E63 F1 F8 F12 F14 F16 F17 F19 F23 F25 F30 F39 F47 F48 G62 H5 H6 H10 H12 H14 H16 H19 H21 H25 H30 H43 H45 H48 H50 H54 H57 H59 H63 J16 J17 J21 J23 J25 J29 J34 J43 J45 J50 J62 K59 K61 L14 L16 L17 L19 L23 L25 L30 L34 L37 L39 L47 L48 L62 M2 M10 M12 M16 M17 M19 M23 M25 M29 M30 M34 M35 M37 M39 M43 M45 M47 M48 M52 M54 M57 M61 M62 N2 N62 P17 P21 P23 P25 P27 P30 P34 P39 P47 P51 P52 P54 P57 P58 P62 R17 R19 R21 R25 R30 R34 R35 R37 R39 R62 R63 T51 T52 T54 T55 T57 V48 V49; U24 J1 J9 L1 L9; U25 J1 J9 L1 L9; U26 J1 J9 L1 L9; U27 J1 J9 L1 L9; U30 4; U32 9 19 20 22 23 43 44 45

## Via types
v1: diameter 0.508, hole 0.254, TOP to BOTTOM, 3492 vias
v2: diameter 0.61, hole 0.356, TOP to BOTTOM, 718 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
1.8V_LDO:
  vias: v1(148.45,37.83)
1.35VSUS_VIN: length 13.8
  IN1 w0.508: v1(106.32,26.64) 106.32,27.18 104.66,28.84 101.71,28.84 101.3,29.24 99.58,29.24 99.04,28.7 97.42,28.7 v2(96.41,29.7)
  BOTTOM w0.508: PR194.1 107.82,27.01 107.38,26.57 106.39,26.57 v1(106.32,26.64)
  vias: v1(94.68,35.46)
3VPCU_VIN:
  vias: v1(126.02,134.7)
5VPCU_VIN:
  vias: v1(140.27,89.18)
+1.2V_ASM: length 14.1
  BOTTOM w0.203: 113.62,35.11 114.25,34.49 U32.13 ; U32.7 112.45,31.14 112.23,30.93 111.37,30.93 C406.2 ; C392.2 119,35.61 119,34.74 118.64,34.39 U32.24 ; C404.2 121.13,31.58 120.77,31.94 U32.28
  BOTTOM w0.381: C406.2 111.37,30.99 111.85,31.47 v1(112.01,31.47)
  BOTTOM w0.508: v1(119.5,35.1) 119.5,35.92 C392.2 ; 113.62,35.11 C388.2 C387.2 112.66,34.8 112.93,34.53 v2(112.93,34.07) ; v1(121.39,32.23) C404.2
  vias: v1(119.34,27.28) v2(112.99,25.04) v2(113.6,25.56)
+1.5V: length 97.3
  TOP w0.203: C257.1 196.82,24.44 196.98,24.44 198.15,25.6 U15.9
  IN2 w0.508: v1(196.8,23.73) 196.2,23.13 194.41,23.13 189.94,27.6 183.15,27.6 v1(182,28.76)
  BOTTOM w0.508: v1(196.8,23.73) 196.8,25.61 197.64,26.45 197.64,30.18 198.21,30.75 198.21,32.97 198.8,33.56 202.7,33.56 203.15,34.01 C397.2 203.9,34.01 204.23,33.68 L8.2 ; Q32.2 191.96,33.12 189.17,30.33 183.58,30.33 182,28.76 v1(182,28.76) 179.18,28.76 174.71,33.23 174.71,38.98 163.82,49.87 149.36,49.87 149.12,49.63 PR181.2
+1.05V: length 24.8
  TOP w0.508: PR27.1 v1(121.41,122.26)
  IN1 w0.508: v1(121.41,122.26) 122.03,121.63 122.03,120.36 118.93,117.25 116.78,117.25 114.46,114.94 114.46,110.05 112.24,107.84 v1(112.24,104.79)
  BOTTOM w0.508: PR27.1 v1(121.41,122.26)
+1.5VA: length 5.6
  TOP w0.203: U15.40 202.89,30.42 203.19,30.71 C220.1
  TOP w0.508: v1(203.85,32.19) 203.85,32.01 203.41,31.57 C220.1
  BOTTOM w0.508: v1(203.41,33.18) 203.19,32.95 C401.1 203.69,32.35 v1(203.85,32.19) 204.14,32.48 L8.1
+1.8V: length 99.4
  TOP w0.279: R112.1 26.68,71.82 27.27,72.4 27.29,72.4 27.43,72.54 27.43,73.42 27.42,73.43 ; 27.42,73.43 Q10.2 29.52,73.43 ; 27.42,73.43 Q10.5 25.86,73.43 25.67,73.61 25.67,74.34 26.37,75.04 R103.1
  TOP w0.508: PQ4.1 47.23,91.85 49.7,94.32 v1(52.15,94.32) 52.15,92.98 55.21,89.92 55.21,89.08 53.96,87.83 R63.1 53.94,87.62 53.3,86.97 v1(53.3,86.73) ; v1(59.67,110.33) 60.82,111.48 60.82,112.6 61.71,113.49 62.22,113.49 64.64,115.92 64.64,116.55 64.64,121.91 62.32,124.23 R4.1 ; v1(39.66,88.1) 39.93,87.84 39.93,86.64 40.12,86.45 PR39.1 41.01,85.36 35.5,79.86 35.5,79.42 v1(34.44,78.35) 29.52,73.43
  IN1 w0.508: v1(53.3,86.73) 51.82,88.21 39.77,88.21 v1(39.66,88.1)
  IN2 w0.508: v1(59.67,110.33) 59.67,103.8 v1(58.91,103.04)
  BOTTOM w0.508: R325.1 59.48,103.04 v1(58.91,103.04) 55.84,103.04 52.28,99.48 52.28,94.46 v1(52.15,94.32)
+1.8V_EMMC: length 10
  TOP w0.254: v1(58.25,95.49) 58.25,95.13 U2.K6
  IN2 w0.508: v1(59.42,101.21) 59.39,101.18 v1(59.39,98.96) 59.68,98.96 60.05,98.59 60.05,95.71 59.18,94.84 58.65,94.84 58.25,95.23 v1(58.25,95.49)
  BOTTOM w0.508: C331.1 58.25,95.49 v1(58.25,95.49)
  vias: v1(59.3,100.06)
+1.8V_S5: length 314
  TOP w0.254: Q15.5 Q15.2 35.33,26.88 v1(35.57,26.63) ; v1(165.57,35.28) U29.1
  TOP w0.279: Q21.2 Q21.5 116.19,18.14
  TOP w0.508: R18.2 73.2,100.61 72.76,100.17 R26.1 ; R18.2 R20.1 ; R18.2 73.79,101.23 R16.2 ; JP11.2 40.89,73.9 42.42,72.36 42.42,56.95 40.34,54.87 40.34,48.99 42.32,47.01 42.32,34.14 v1(40.43,32.25) ; v1(165.57,35.28) 165.57,35.88 R418.1 ; R25.1 86.17,99.97 R27.2 84.95,99.97 84.35,99.37 R28.2 83.9,99.77 83.67,100 82.7,100 82.4,100.3 82.4,100.68 82.09,101 80.76,101 R23.2 80.02,100.29 79.49,100.82 77.8,100.82 77.59,100.61 R17.2 R19.1 75.85,101.89 75.43,102.31 74.61,102.31 74.2,101.9 R16.2 ; v1(44.17,30.53) 44.41,30.78 PR50.2 ; v1(116.56,16.48) 116.56,17.77 116.19,18.14 ; 34.63,98.46 36.84,98.46 38.16,99.78 40.19,99.78 40.7,99.27 40.7,94.08 35.72,89.1 35.72,84.2 v1(32.02,80.49) ; R16.2 73.98,101.65 v1(72.59,103.04)
  IN1 w0.508: v1(165.29,25.56) 163.64,27.21 163.64,34.37 164.54,35.28 v1(165.57,35.28) ; v1(38.38,80.49) v1(32.02,80.49)
  IN3 w0.508: v1(165.29,25.56) 165.29,25.02 163.66,23.4 152.26,23.4 151.62,22.76 150.63,22.76 149.6,21.73 147.51,21.73 146.52,22.71 141.68,22.71 141.13,23.26 141.13,24.03 140.51,24.65 136.05,24.65 135.08,23.69 133.8,23.69 133.56,23.44 130.79,23.44 128.21,26.02 123.02,26.02 122.76,25.76 122.44,25.76 118.54,21.86 118.54,16.91 118.1,16.48 v1(116.56,16.48) 84.39,16.48 81.42,13.5 47.47,13.5 44.06,16.92 44.06,18.5 44.87,19.31 44.87,29.47 44.17,30.17 v1(44.17,30.53) 43.69,30.05 41.03,30.05 40.43,30.66 v1(40.43,32.25)
  BOTTOM w0.508: v1(68.13,98.32) 68.45,98.63 R356.1 ; v1(63.88,84.61) R390.1 64.58,85.6 64.6,85.58 R391.1 ; R392.1 67.96,85.58 68.5,85.04 v1(68.5,84.95) ; v1(109.62,87.33) 109.86,87.57 109.86,88.59 R377.2 ; v1(68.13,97.34) 68.51,97.34 68.79,97.62 R360.1 R363.2 R366.2 ; v1(40.43,32.25) 40.43,27.95 39.11,26.63 v1(35.57,26.63) ; R384.2 69.19,86.98 v1(69.57,86.6) ; R398.1 R397.1 59.88,75.29 v1(59.54,74.95) ; R328.2 R327.2 73.21,103.04 v1(72.59,103.04) 72.25,103.38 v1(72,103.38) ; R381.1 56.38,88.77 55.7,89.45 v1(54.05,89.45)
  vias: v1(41.26,82.63) v1(53.39,89.45) v1(58.58,83.4) v1(59.23,83.39) v1(67.25,80.9) v1(67.9,80.9) v1(68.56,80.9) v1(83.4,104.72) v1(84.38,104.74) v1(85.03,104.74)
+1.24V_S5:
  vias: v1(121.68,80.83)
+1.35VSUS: length 45.9
  TOP w0.305: U11.K8 113.22,51.08 v1(112.85,51.44) ; v1(112.06,53.07) 112.06,53.08 112.46,53.48 U11.G7 ; U11.D2 108.44,55.88 108.05,55.48 v1(108.05,55.48) ; v1(77.68,51.44) 78.04,51.08 U9.K8 ; v1(59.76,57.88) 60.16,58.28 U8.A8 ; v1(59.77,51.52) 60.17,51.13 U8.K8 ; v1(77.67,57.9) 78.04,58.28 U9.A8 ; U11.A8 113.22,58.28 v1(112.84,57.9) ; U10.K2 90.6,51.08 v1(90.95,51.43) ; v1(90.14,55.48) 90.14,55.48 90.54,55.88 U10.D2 ; U9.G7 77.25,53.48 76.85,53.08 v1(76.85,53.07) ; U8.K2 55.42,51.08 v1(55.77,51.43) ; U8.D2 55.36,55.88 54.96,55.48 v1(54.96,55.48) ; U10.K8 95.35,51.13 v1(94.95,51.53) ; U11.K2 108.46,51.13 v1(108.86,51.53) ; U10.G7 94.52,53.48 94.12,53.08 v1(94.12,53.07) ; v1(114.59,47.08) U11.R9 ; U10.C9 96.16,56.68 v1(96.56,57.08) ; v1(58.95,53.07) 58.95,53.08 59.35,53.48 U8.G7 ; 96.55,55.48 v1(96.56,55.48) ; 96.55,55.48 U10.D9 ; 96.55,55.48 U10.E9 ; U10.A8 95.34,58.28 v1(94.94,57.88) ; v1(73.68,51.53) 73.28,51.13 U9.K2
  TOP w0.508: v1(49.48,55.01) 49.92,54.56 R152.1 ; v1(119.37,57.81) C136.1 ; v1(96.56,55.48) 97.24,55.48 ; R106.1 90.67,74.7 90.86,74.51 R105.1
  BOTTOM w0.254: v1(99.14,80.57) 99.11,80.57 U21.AV14 98.73,81.46 U21.AT13 ; U21.AT47 82.92,81.93 82.84,81.93 v1(82.61,82.17) 82.81,82.37 U21.AR47
  BOTTOM w0.305: v1(95.75,53.07) 95.75,53.08 U26.H2 ; U11.K8 113.22,51.08 v1(112.85,51.44) ; v1(90.95,51.43) 90.91,51.43 U10.K2 ; v1(94.95,51.53) 95.35,51.13 U10.K8 ; U10.R9 96.86,47.08 97.32,47.54 v1(97.32,47.88) 97.32,48.15 96.79,48.68 U10.N9 ; U11.R1 106.76,47.08 106.4,47.43 v1(106.4,47.97) 106.4,48.34 106.74,48.68 U11.N1 ; v1(108.04,53.07) 107.66,52.68 U27.H9 ; U26.G7 91.35,53.47 v1(91.75,53.07) ; U11.K2 108.46,51.13 v1(108.86,51.53) ; U9.N1 71.82,48.68 71.31,48.16 v1(71.31,47.88) 71.31,47.79 72.03,47.08 U9.R1 ; U27.D2 v1(112.86,56.28) ; v1(77.68,56.28) U25.D2 ; U25.G7 74.08,53.47 v1(74.48,53.07) ; U27.G7 109.26,53.45 v1(109.63,53.08) ; v1(72.86,53.07) 72.48,52.68 U25.H9 ; v1(78.48,53.07) 78.48,53.08 U25.H2 ; U26.B2 95.34,57.48 v1(94.94,57.88) ; U27.B2 113.26,57.49 v1(112.84,57.9) ; U8.K2 55.37,51.08 55.73,51.43 v1(55.77,51.43) ; U24.D2 60.16,55.88 v1(59.76,55.48) ; U24.G7 56.17,53.43 v1(56.52,53.08) ; U24.B2 60.16,57.48 v1(59.76,57.88) ; U21.AV50 81.67,81.46 U21.AT51 81.47,81.66 v1(81.89,82.08) ; v1(89.22,47.08) U10.R1 ; v1(77.67,57.9) 78.08,57.49 U25.B2 ; v1(59.77,51.52) 60.17,51.13 U8.K8 ; v1(77.68,51.44) 78.04,51.08 U9.K8 ; v1(94.94,55.48) 95.34,55.88 U26.D2 ; v1(73.68,51.53) 73.28,51.13 U9.K2
  vias: v1(46.36,59.62) v1(49.38,59.64) v1(50,49.64) v1(50,48.59) v1(50.57,50.65) v1(51.3,51.31) v1(51.42,47.35) v1(52.35,47.32) v1(54.02,48.51) v1(54.04,47.08) v1(54.15,58.65) v1(54.15,57.07) v1(54.96,58.68) v1(54.96,57.88) v1(54.96,53.07) v1(60.57,53.07) v1(61.38,57.08) v1(61.38,56.3) v1(61.38,55.48) v1(61.38,53.88) v1(61.38,53.07) v1(61.46,58.51) v1(62.14,47.88) v1(72.04,56.32) v1(72.05,58.7) v1(72.05,57.07) v1(72.87,58.68) v1(72.87,57.88) v1(72.87,55.48) v1(79.29,57.09) v1(79.29,56.28) v1(79.29,55.47) v1(79.37,59.13) v1(79.42,48.36) v1(79.41,47.08) v1(82.36,76.08) v1(82.45,46.91) v1(83.18,46.91) v1(83.47,44.45) v1(84.57,82.59) v1(86.04,76.28) v1(86.45,40.19) v1(86.49,82.67) v1(86.48,51.31) v1(86.8,71.14) v1(86.81,70.42) v1(86.95,50.06) v1(89.17,48.51) v1(89.3,57.04) v1(89.31,56.3) v1(90.03,70.06) v1(90.01,69.41) v1(90.14,57.88) v1(90.14,53.07) v1(95.91,82.7) v1(96.56,58.68) v1(96.56,56.3) v1(96.56,53.88) v1(96.56,53.07) v1(96.71,82.68) v1(100.53,28.61) v1(100.99,28.16) v1(107.23,58.7) v1(107.23,57.07) v1(107.23,56.32) v1(107.3,54.68) v1(107.71,41.53) v1(108.04,58.68) v1(108.04,57.88) v1(112.61,40.19) v1(113.66,53.07) v1(114.47,58.72) v1(114.47,57.09) v1(114.47,56.28) v1(114.47,55.47) v1(114.6,48.36) v1(116.79,42.48) v1(117.27,42.93) v1(119.31,45.56) v1(119.37,56.79) v2(79.84,41.02) v2(79.92,69.49) v2(79.9,68.69) v2(80.76,67.34) v2(82.12,42.15) v2(84.52,41.05) v2(84.52,33.63) v2(85.29,43.82) v2(85.28,33.63) v2(86.04,33.63) v2(86.8,33.63) v2(87.24,42.21) v2(87.57,33.63) v2(88.33,33.63) v2(88.93,41) v2(89.09,33.63) v2(108.48,69.92) v2(108.48,69.1) v2(108.48,68.3) v2(108.48,67.37) v2(108.48,65.74) v2(108.48,64.46) v2(108.48,63.16) v2(108.48,61.62)
+1.35VSUS_SRC: length 25.5
  IN2 w0.508: v1(82.25,29.82) 83.04,30.61 101.74,30.61 102.19,31.06 105.69,31.06 v1(105.9,31.27)
  BOTTOM w0.508: PR190.2 105.49,31.69 v1(105.9,31.27)
+3V: length 394.7
  TOP w0.279: U6.18 28.45,62.2 28.11,61.85 ; 30.65,61.69 30.65,61.99 30.45,62.18 U6.22
  TOP w0.305: U17.8 156.18,19.25 155.99,19.44 v1(155.99,19.61) ; 153.51,12.49 155.87,12.49 156.18,12.8 U17.14 ; C280.1 161.04,14.17 U17.1 ; C277.1 150.79,15.22
  TOP w0.508: v1(21.92,59.77) 21.71,59.55 16.53,59.55 C128.2 C137.2 16.22,57.87 17,58.65 Q13.2 ; v1(133.96,39.19) 133.96,39.89 134.68,40.62 135.6,40.62 136.16,40.06 R176.2 ; 150.79,15.22 150.79,14.97 153.26,12.49 153.51,12.49 ; v1(162.17,19.54) 162.17,20.94 167.58,26.34 v1(167.58,28.35) ; R66.1 58.8,86.58 59.04,86.82 Q5.2 57.52,89.11 57.52,91.09 55.33,93.28 54.06,93.28 53.26,94.09 53.26,95.27 52.48,96.05 v1(51.53,96.05) ; v1(47.43,109.21) 47.22,109 R7.2 ; v1(214.97,34.79) 215.25,34.51 R222.1 R223.1 ; v1(81.04,101.66) 82.36,101.66 82.68,101.34 89.66,101.34 90.08,100.92 R21.2 90.92,100.55 R22.2 ; 192.67,30.69 182.54,30.69 180.35,32.87 v1(177.49,32.87) ; 192.67,30.69 192.67,33.95 192.16,34.46 192.16,38.01 193.28,39.13 v1(194.22,39.13) ; 192.67,30.69 R238.2 ; 29.46,60.24 29.46,57.84 v1(28.54,56.91) ; R177.2 138.81,41.41 138.44,41.77 v1(138.44,42.85) ; v1(21.23,32.02) 21.84,31.42 R234.1 ; v1(162.17,13.68) C280.1 ; v1(66.08,93.27) 66.08,93.86 66.41,94.19 R45.2 66.42,94.6 66.85,95.02 R38.2 66.85,97.02 v1(66.53,97.34) 66.53,99.5 63.01,103.03 60.67,103.03 59.57,101.93 57.6,101.93 57.16,101.49 57.16,101.39 v1(56.77,100.99) 56.63,101.13 54.15,101.13 51.4,98.38 v1(51.4,97.86) ; R3.1 65.78,125.19 v1(65.83,125.24) ; v1(25.66,71.23) 25.54,71.12 C109.2 R119.2 ; R231.1 164.13,31.94 164.55,32.37 v1(164.55,32.87) ; R224.1 37.6,33.3 38.48,32.41 v1(38.74,32.41) 41.02,34.69 41.02,46.48 39.05,48.45 39.05,59.19 39.04,59.19 39.21,59.36 ; v1(151.45,16.06) 151.45,15.96 151.03,15.54 C277.1
  IN1 w0.508: v1(121.41,121.37) 121.41,120.59 118.68,117.86 116.53,117.86 112.35,113.69 v2(112.35,111.19) ; v1(164.55,32.87) 164.55,31.88 167.58,28.86 v1(167.58,28.35) 167.58,28 171.16,24.41 179.56,24.41 ; v1(138.97,51.05) 137.54,49.61 137.54,45.03 137.97,44.6 139.21,44.6 v1(139.7,44.11) v1(138.44,42.85) 137.62,42.85 v1(133.96,39.19) 133.3,39.19 132.56,38.46 132.56,37.23 131.81,36.49 131.81,34.49 130.04,32.72 127.98,32.72 127,33.7 125,33.7 122.77,31.47 119.69,31.47 115.32,27.1 115.32,26.08 111.9,22.66 108.66,22.66 v1(107.82,23.51)
  IN2 w0.508: v1(155.99,19.61) 155.69,19.92 152.56,19.92 150.58,17.94 150.58,16.36 150.89,16.06 v1(151.45,16.06) ; v2(113.1,109.68) 116.5,109.68 118.15,108.02 v1(123.48,108.02) ; v1(194.22,39.13) 194.78,39.69 200.67,39.69 201.69,40.71 204.43,40.71 205.07,40.07 v1(207.03,40.07) 207.03,40.6 207.41,40.97 215.18,40.97 215.56,40.6 215.56,36.05 214.97,35.46 v1(214.97,34.79)
  IN3 w0.508: v1(155.99,19.61) 155.99,20.15 156.4,20.55 161.29,20.55 162.17,19.67 v1(162.17,19.54) v1(162.17,13.68)
  BOTTOM w0.279: Q29.2 v1(66.53,97.34) ; v1(66.08,93.27) 66.08,93.63 66.52,94.07 66.52,94.41 Q29.5
  BOTTOM w0.381: R332.2 77.22,101.68 v1(77.37,101.68) ; v1(81.04,101.66) 80.7,101.32 R337.2 ; R336.2 78.62,101.32 v1(78.88,101.58)
  BOTTOM w0.508: v1(21.92,59.77) 24.78,56.91 v1(28.54,56.91) ; v1(121.41,121.37) 121.41,120.73 PR129.1 121.41,120.51 120.49,119.59 PR131.1 ; R487.2 v1(110.35,108.41) ; v1(103.71,106) 103.36,106 102.98,106.38 R300.2 ; v1(65.83,125.24) R276.1 v1(66.55,125.94) ; v1(133.96,39.19) 133.34,39.19 133.22,39.07 R443.2 ; PR144.1 v1(123.48,108.02) ; R289.2 v1(106.79,108.41) R488.2 ; v1(21.23,32.02) 21.7,31.55 23.57,31.55 24.95,32.93 30.45,32.93 32.27,34.75 33.18,34.75 35.52,32.41 v1(38.74,32.41) ; v1(62.27,120.38) 62.72,120.82 R279.2 ; R353.1 56.67,100.9 v1(56.77,100.99) ; PR197.1 v1(107.82,23.51) ; R416.1 206.59,40.51 v1(207.03,40.07) ; v1(36.09,72.97) 34.8,72.97 32.75,75.01 31.61,75.01 30.34,73.74 29.83,73.74 29.32,73.23 28.05,73.23 26.05,71.23 v1(25.66,71.23) ; v1(139.7,44.11) 139.19,43.6 PR186.1 ; v1(115.15,80.13) 114.84,79.81 C352.1 114.84,79.12 114.84,76.19 115.32,75.71 U23.4 ; R299.2 v1(76.32,107.73) ; R297.2 v1(78.56,107.73)
  vias: v1(36.74,73.02) v1(37.39,73.05) v1(38.03,73.04) v1(67.15,108.97) v1(67.8,108.98) v1(80.46,107.83) v1(114.18,110.9) v1(177.79,32.11) v1(197.13,19.75) v1(197.7,19.28) v1(198.08,19.82) v2(89.29,108.35) v2(89.29,107.24) v2(89.79,107.8) v2(112.35,110.43) v2(113.1,111.2) v2(113.1,110.44) v2(229.78,24.59) v2(229.78,23.83)
+3V_ASM: length 12.4
  BOTTOM w0.203: U32.39 117.85,26.65 ; U32.27 120.56,32.34 121.1,32.88 C400.1 ; C390.1 117.49,35.81 116.32,34.64 116.3,34.64 116.25,34.58 U32.18 ; v1(112.35,29.72) 112.57,29.94 U32.4 ; U32.14 114.64,34.83 114.42,35.06 114.42,35.85 C389.2
  BOTTOM w0.508: v1(114.99,35.37) 114.99,35.61 C389.2 ; v1(118.39,35.04) 118.45,35.1 C391.2 C390.1 ; v1(121.39,33.52) C400.1
  vias: v1(112.36,28.18) v1(113.19,30.18) v1(117.17,26.02) v1(119.65,33.58) v1(121.22,29.58) v2(112.06,34.07)
+3V_CR:
  vias: v1(24.34,31.86)
+3V_EC: length 1.2
  TOP w0.203: U16.11 130.23,26.46
  vias: v1(128.38,26.29)
+3V_EMMC: length 1.6
  TOP w0.254: v1(58.11,96.43) 58.39,96.14 U2.M6 ; U2.N5 58.84,96.49 58.25,97.08 v1(58.11,97.08)
  vias: v1(55.92,96.83) v1(56,98.88) v1(55.96,97.73) v1(56.58,97.16) v1(57.41,97.05)
+3V_LDO_EC: length 47.4
  TOP w0.254: v1(131.92,37.52) 131.92,37.7 132.64,38.41 R202.2 v1(132.64,39.58)
  TOP w0.381: R212.2 v1(141.5,37.07) 141.59,37.17 141.59,38.01 141.15,38.44 R206.2 R211.2
  TOP w0.508: R213.2 v1(144.31,36.41)
  IN2 w0.508: v1(131.92,37.52) 132.66,36.77 136.21,36.77 136.86,37.42 141.15,37.42 v1(141.5,37.07) 143.65,37.07 v1(144.31,36.41) 147.18,33.54 148.61,33.54 149.45,32.7 v1(150.27,32.7)
  BOTTOM w0.254: v1(131.92,37.52) 131.92,36.94 133.82,35.04 133.82,34.96 134.35,34.42 134.35,31.15 133.42,30.21 132.31,30.21 131.94,30.59 131.33,30.59 131.13,30.39 D24.1 131.13,29.37 132.12,28.38 R462.2
  BOTTOM w0.508: R450.2 150.48,32.91 v1(150.27,32.7) 150.27,31.97 149.64,31.34 R459.1
+3V_M2: length 12.9
  IN2 w0.508: v1(26.06,95.03) 27.67,93.43 31.63,93.43 v1(32.55,92.51)
  BOTTOM w0.508: 37.17,90.78 36,91.95 33.11,91.95 v1(32.55,92.51)
+3V_RTC: length 265.2
  TOP w0.508: v1(46.07,41.05) 47.1,41.05 52.61,35.54 102.37,35.54 103.62,36.79 113.77,36.79 114.22,37.25 115.62,37.25 120.68,42.31 128.82,42.31 130.55,40.58 131.21,40.58 131.75,40.04 131.75,38.26 131.17,37.68 v1(131.17,36.68) ; R246.1 189.46,27.14 v1(188.79,26.46) 188.79,26.78 188.42,27.14 R245.1 188.07,27.59 187.69,27.97 175.49,27.97 175.06,28.4 v1(170.17,28.4)
  IN2 w0.508: v1(131.17,36.68) 131.17,38 131.68,38.51 132.34,38.51 133.66,39.82 138.85,39.82 140.11,38.56 v1(147.58,38.56) 148.58,37.56 148.58,35.73 151.44,32.86 152.23,32.86 154.02,31.07 155.99,31.07 156.91,31.99 158.74,31.99 161.18,29.55 167.37,29.55 168.52,28.4 v1(170.17,28.4)
  IN3 w0.508: v1(44.94,65.99) 44.94,66.49 51.8,73.36 51.8,75.92 49.72,78 49.72,81.87 50.22,82.37 50.22,82.65 52.62,85.05 62.95,85.05 63.15,85.25 64.13,85.25 64.5,85.62 70.5,85.62 71.01,86.12 72.95,86.12 73.04,86.03 75.57,86.03 76.1,86.57 81.84,86.57 83.88,88.61 v1(84.28,88.61)
  BOTTOM w0.203: U21.AA44 84.64,88.25 v1(84.28,88.61)
  BOTTOM w0.508: v1(131.17,36.68) 131.44,36.68 131.82,36.3 131.82,35.14 R455.2 ; D26.3 188.9,26.87 188.79,26.76 v1(188.79,26.46) ; v1(44.94,65.99) 41.8,62.85 41.8,46.31 46.07,42.04 v1(46.07,41.05) ; R446.2 146.66,31.97 145.4,33.23 144.39,33.23 143.88,33.74 143.88,34.24 144.16,34.53 145.43,34.53 145.96,35.06 145.96,37.55 146.98,38.56 v1(147.58,38.56)
+3V_RTC_1: length 2.4
  BOTTOM w0.508: D26.1 191.35,26.43 v1(192.15,26.43) 192.28,26.56 R463.2
+3V_S5: length 268.7
  TOP w0.508: R50.1 R51.1 30.08,93.94 30.67,93.35 30.67,92.06 R56.1 v1(30.68,91.39) ; v1(31.66,85) 31.66,85.42 R69.1 ; R259.2 114.83,20.12 R264.2 ; R259.2 R258.2 ; R259.2 C266.1 115.97,20.74 116.74,21.51 118.14,21.51 118.48,21.17 ; R65.1 23.74,86.45 23.74,85.3 24.24,84.79 R76.1 24.46,84.79 v1(25.19,84.79) R77.1 ; v1(28.37,84.14) 28.69,84.45 R79.1 R80.1 ; v1(68.54,83.43) 68.96,83.01 R85.2 R82.1 R81.1 ; v1(131.7,45.04) 132.83,45.04 133.22,44.65 134.49,44.65 134.6,44.76 143.48,44.76 143.76,45.04 148.19,45.04 148.79,44.44 148.79,41.07 150.61,39.25 150.61,36.26 150.19,35.84 150.19,35.31 150.61,34.9 150.61,33.36 150.92,33.05 150.92,32.04 152.52,30.43 R236.2 ; R261.2 106.64,20.91 v1(106.4,20.67) ; R67.2 68.36,86.14 v1(68.54,86.31) 68.79,86.06 R71.1
  IN1 w1.016: 40.73,33.65 80.54,33.65 81.47,32.72 100.9,32.72 ; 129.55,92.56 126.72,89.72 126.72,70.14 130.06,66.79 130.06,54.39 132.54,51.92 132.54,48.94 131.73,48.12 131.73,45.07 v1(131.7,45.04) 131.7,44.07 128.03,40.41 120.19,40.41 118.04,38.26 118.04,36.77 115.29,34.02 114.31,34.02 112.84,32.55
  IN2 w0.508: 63.57,87.41 67.45,87.41 v1(68.54,86.31)
  IN3 w1.016: v2(121.43,109.48) v2(122.43,109.48) 123.26,109.48 126.17,112.4 127.81,112.4 129.58,110.63 129.58,109.34 130.77,108.15 130.77,94.23
  BOTTOM w0.508: v1(62.64,90.31) 61.96,90.99 61.96,93.54 63.96,95.54 R365.2 ; v1(63.52,91.53) 63.52,93.1 R368.2 ; v1(49.19,86.87) 46.97,84.65 PR160.1 ; PR149.1 131.26,92.97 v2(130.78,92.97) ; R389.2 68.56,86.31 v1(68.54,86.31) ; v1(68.54,83.43) 68.37,83.43 67.78,82.84 65.18,82.84 64.82,82.48 v1(60.89,82.48)
  BOTTOM w1.016: v2(122.43,109.48) v2(121.43,109.48) 121.42,109.48 114.59,109.48 113.83,108.73 112.7,108.73 111.36,110.07 111.36,115.26 112.39,116.29 114.26,116.29
  vias: v1(38.61,33.2) v1(39.07,33.65) v1(60.23,82.48) v1(104.15,20.66) v1(104.8,20.67) v1(105.76,29.42) v1(106.41,29.43) v1(114.24,118.17) v2(34.26,57.06) v2(34.96,56.78) v2(38.43,86.72) v2(39.23,87.43) v2(130.78,92.21)
+3VPCU: length 475.5
  TOP w0.203: U15.20 202.49,22.89 203.15,22.22 v1(203.15,22)
  TOP w0.508: v1(129.16,39.45) 128.44,40.17 120.25,40.17 116.12,36.04 114.72,36.04 114.27,35.59 104.21,35.59 102.96,34.33 82.38,34.33 v1(81.77,33.72) ; PR80.2 40.21,15.67 40.33,15.78 PR81.2 41.02,15.12 v1(41.05,15.1) ; R11.2 43.23,107.41 42.79,106.96 42.79,100.56 43.37,99.98 43.37,94.95 v1(40.17,91.75) ; v1(44.93,81.78) 45.42,82.27 PR41.1 ; v1(39.81,26.19) 40.03,26.41 PR56.2 40.49,25.77 40.53,25.73 PR60.2 ; v1(27.75,58.6) 27.23,58.6 26.01,59.82 24.91,59.82 24.19,59.11 22.9,59.11 21.34,57.55 21.34,57.13 v1(20.9,56.69) 19.18,56.69 18.8,56.32 18.8,55.07 R151.2 ; PR63.2 36.75,23.67 v1(38.41,23.67) ; v1(38.84,28.73) 39.39,28.18 PC42.1 ; PR62.2 v1(42.87,25.95) ; PR79.2 v1(73.77,14.22)
  IN1 w0.508: v1(73.77,14.22) 47.36,14.22 45.95,15.63 41.57,15.63 v1(41.05,15.1) ; v2(132.78,54.99) 134.11,53.67 134.11,43.3 133.35,42.54 132.25,42.54 v1(129.16,39.45) ; v1(20.9,56.69) 20.9,53.05 19.08,51.23 19.08,33.31 27.81,24.58 37.56,24.58 38.12,24.03 38.12,23.96 v1(38.41,23.67) ; v1(34.73,84.13) 34.73,84.13 42.58,84.13 v1(44.93,81.78)
  IN2 w0.508: v1(221.36,17.1) 220.05,17.1 218.77,15.82 213.94,15.82 213.33,16.43 205.07,16.43 v1(203.14,18.37) 203.14,21.98 v1(203.15,22) ; v1(129.16,39.45) 128.28,39.45 127.28,38.45 126.9,38.45 125.58,37.14 125.58,34.67 126.44,33.81 127.04,33.81 128.33,32.52 133.52,32.52 135.4,30.64 136.06,30.64 136.8,29.9 141.37,29.9 143.67,27.61 145.46,27.61 145.69,27.38 150.42,27.38 150.61,27.19 152.54,27.19 153.74,25.99 157.27,25.99 157.83,26.56 160.39,26.56 160.4,26.56 163.9,26.56 164.17,26.29 172.93,26.29 177.99,21.24 177.99,17.58 178.75,16.82 181.16,16.82 183.45,19.11 v1(183.45,19.41)
  IN3 w0.508: v1(38.84,28.73) 38.84,27.17 v1(39.81,26.19) 39.81,25.07 v1(38.41,23.67) 38.41,22.61 39.24,21.77 39.24,16.91 v1(41.05,15.1) ; v2(124.63,119.64) 129.73,119.64 132.04,121.94 132.04,124.81 130.79,126.06 130.79,130.71 131.27,131.19 131.27,135.79 v1(130.91,136.16) ; v1(183.45,19.41) 193.9,19.41 195.2,20.71 197.66,20.71 200,18.37 v1(203.14,18.37) ; v1(27.75,58.6) 26.53,59.82 26.53,67.39 28.92,69.78 30.32,69.78 30.68,70.14 30.68,74.25 31.53,75.1 31.53,77.38 32.12,77.96 32.12,78.65 32.66,79.19 32.66,81.22 33.34,81.9 33.34,82.74 v1(34.73,84.13) 37.34,86.74 37.34,88.13 40.17,90.96 v1(40.17,91.75)
  BOTTOM w0.279: 221.01,17.1 220.85,17.26 CN17.7
  BOTTOM w0.508: v1(221.36,17.1) 221.01,17.1 ; v1(129.63,90.78) 129.63,91.04 129.95,91.36 PR150.1 ; v1(81.77,33.72) 81.27,33.23 53.84,33.23 46.56,25.95 v1(42.87,25.95) 42.1,25.18 40.83,25.18 v1(39.81,26.19) ; v1(129.16,39.45) 130.07,39.45 130.45,39.08 130.45,36.04 129.77,35.37 R454.2 ; D26.2 190.78,28.33 187.52,28.33 183.99,24.8 183.99,23.11 185.1,22 185.1,19.94 184.57,19.41 v1(183.45,19.41) ; PR88.1 v1(130.91,136.16)
  vias: v1(118.63,110.95) v1(118.73,117.91) v2(121.26,110.45) v2(122.02,110.45) v2(122.53,112.19) v2(122.53,111.43) v2(123.29,111.43) v2(123.79,118.85) v2(123.79,118.09) v2(123.79,117.33) v2(124.63,118.88) v2(124.63,118.12) v2(124.63,117.36) v2(124.63,116.59) v2(127.95,100.18) v2(127.95,99.42) v2(128.53,98.95) v2(129.29,98.95) v2(132.12,56.13) v2(132.12,55.37) v2(132.12,54.6) v2(132.77,55.74)
+3VPCU_EC: length 45
  TOP w0.203: U16.114 138.68,33.12 138.77,33.21 138.77,34.12 138.52,34.36 C205.1 ; 135.88,32.98 U16.121 ; v1(140,17.58) 139.88,17.46 U16.50 ; 148.2,28.97 148.09,28.86 U16.92 ; U16.26 132.51,20.46 132.57,20.4 v1(132.6,20.4)
  TOP w0.305: 135.88,32.98 135.74,33.12 135.28,33.12 135.02,33.38 C209.1 135.53,33.73 v1(135.53,33.65) ; 148.2,28.97 v1(148.29,29.06) 148.29,29.11 v1(148.75,29.57) ; L4.2 133.01,37.75 v1(133.3,38.04)
  TOP w0.508: C205.1 138.26,33.72 v1(138.29,33.69)
  IN2 w0.305: v1(135.53,33.65) 136.06,33.12 136.91,33.12 137.48,33.69 v1(138.29,33.69) 138.29,32.97 138.67,32.59 142.19,32.59 142.75,32.03 146.12,32.03 148.29,29.86 v1(148.29,29.06)
  BOTTOM w0.305: v1(136.2,23.65) 135.9,23.94 135.9,25.38 135.25,26.04 135.25,27.46 134.72,27.98 134.72,29.99 135.53,30.8 v1(135.53,33.65) 135.53,34.72 134.86,35.39 134.86,35.62 133.11,37.36 133.11,37.86 v1(133.3,38.04)
