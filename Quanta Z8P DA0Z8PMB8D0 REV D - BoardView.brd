# Allegro board Quanta Z8P DA0Z8PMB8D0 REV D - BoardView.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on BOTTOM (solid shape): 77.72,92.7 77.72,92.22 77.24,91.74 77.24,91.62 77.21,91.56 77.2,91.49 77.09,91.38 77.09,91.33 77.08,91.3 77.07,91.28 77.02,91.25 76.94,91.22 76.87,91.25 76.76,91.35 76.62,91.4 76.59,91.41 76.58,91.45 76.58,91.64 76.61,91.67 76.62,91.67 76.71,91.73 76.77,91.81 76.77,91.83 76.99,92.04 76.99,92.07 77.14,92.22 77.14,92.68 77.04,92.78 77.04,92.93 77.14,93.03 77.39,93.03
GND on BOTTOM (solid shape): 140.65,50.81 140.65,50.53 140.6,50.47 140.6,45.45 140.78,45.27 143.85,45.27 144.13,45.55 144.77,45.55 145.05,45.27 145.05,44.21 144.64,43.81 140.14,43.81 140.05,43.85 140.05,43.95 139.92,44.42 139.43,44.38 139.03,43.98 138.41,43.98 137.91,44.48 137.91,49.33 137.91,50.37 138.01,50.47 138.94,50.47 139.26,50.8 139.45,50.98 140.47,50.98
GND on BOTTOM (solid shape): 143.57,88.14 143.57,84.87 142.51,83.8 142.51,83.6 142.48,83.57 142.48,82.91 142.51,82.89 142.51,82.61 142.58,82.53 142.94,82.53 143.01,82.45 143.01,81.31 142.94,81.23 142.56,81.23 142.51,81.18 142.51,80.85 142.48,80.82 142.48,80.17 142.47,80.14 142.46,80.12 142.25,80.12 142.23,80.14 142.23,80.17 142.23,80.82 142.23,81.18 142.18,81.23 141.77,81.23 141.72,81.29 141.72,82.86 141.73,82.89 141.74,82.9 142.23,82.91 142.23,83.57 142.03,83.57 142.03,82.91 141.78,82.91 141.78,83.57 141.74,83.58 141.73,83.6 141.72,83.63 141.72,84 141.39,84.33 141.39,88.37 141.54,88.52 143.19,88.52
GND on BOTTOM (solid shape): 58.01,116.12 58.01,113.19 57.66,112.84 54.7,112.84 54.34,113.2 54.34,114.9 55.99,114.9 55.99,114.85 56,114.79 56.02,114.74 56.05,114.69 56.08,114.64 56.12,114.6 56.16,114.57 56.21,114.54 56.26,114.52 56.32,114.51 56.37,114.51 56.43,114.51 56.48,114.52 56.54,114.54 56.58,114.57 56.63,114.6 56.67,114.64 56.7,114.69 56.73,114.74 56.74,114.79 56.75,114.85 56.76,114.9 56.75,114.96 56.74,115.01 56.71,115.06 56.68,115.11 56.65,115.15 56.61,115.19 56.56,115.22 56.51,115.25 56.46,115.26 56.4,115.27 56.35,115.27 56.29,115.26 56.24,115.25 56.19,115.22 56.14,115.19 56.1,115.15 56.06,115.11 56.03,115.06 56.01,115.01 56,114.96 55.99,114.9 54.34,114.9 54.34,115.6 54.36,115.64 54.38,115.69 54.38,115.75 54.38,115.81 54.38,115.87 54.36,115.92 54.34,115.96 54.34,115.98 53.88,116.44 53.88,116.77 54.01,116.9 57.24,116.9
GND on BOTTOM (solid shape): 118.05,118.69 118.05,117.84 118.05,117.82 118.04,117.8 118,117.76 118,116.25 117.73,115.98 117.73,115.07 117.8,115 117.8,114.92 117.79,114.91 117.75,114.78 117.79,114.65 117.8,114.64 117.8,114.52 117.79,114.51 117.75,114.38 117.79,114.25 117.8,114.24 117.8,114.12 117.79,114.11 117.75,113.98 117.79,113.85 117.8,113.84 117.8,113.77 117.73,113.69 117.73,113.07 117.99,112.8 117.99,110.95 117.99,110.95 117.99,110.31 117.8,110.12 116.39,110.12 116.38,110.12 116.38,110.23 116.39,110.23 116.39,112.67 116.68,112.96 116.68,115.06 116.72,115.11 116.72,115.87 116.68,115.91 116.68,115.94 116.42,116.2 116.41,116.21 116.41,116.23 116.41,118.7 116.67,118.96 117.78,118.96
GND on BOTTOM (solid shape): 128.78,139.03 128.78,137.19 128.66,137.07 128.66,134.68 128.38,134.4 128.38,133.99 128.38,133.99 128.38,133.33 128.38,133.33 128.38,133.1 128.48,133 128.89,133 128.92,132.97 128.92,131.65 128.87,131.6 128.48,131.6 128.46,131.63 128.38,131.55 128.38,131.24 128.38,131.24 128.38,130.66 128.37,130.63 128.36,130.62 128.15,130.62 128.14,130.63 128.13,130.66 128.13,131.24 128.13,131.24 128.13,131.58 128.08,131.63 127.62,131.63 127.6,131.65 127.6,133.21 127.61,133.21 127.67,133.33 127.93,133.33 128.13,133.33 128.13,133.99 127.93,133.99 127.93,133.33 127.68,133.33 127.68,133.99 127.67,133.99 127.67,134.37 127.49,134.55 127.49,134.63 127.24,134.88 127.19,134.89 127.17,134.9 127.16,134.93 127.16,135.41 126.73,135.84 126.73,139.4 126.96,139.63 128.17,139.63
GND on BOTTOM (solid shape): 72.53,54.49 72.55,54.48 72.57,54.46 72.71,54.34 72.9,54.31 72.92,54.31 72.94,54.3 73,54.23 73,54.22 73.08,54.08 73.22,54 73.23,54 73.47,53.77 73.47,53.38 73.46,53.36 73.45,53.34 73.39,53.27 73.34,53.19 73.26,53.17 73.19,53.22 73.12,53.32 73.03,53.39 72.69,53.38 72.51,53.09 72.51,53.07 72.37,52.94 72.32,52.91 72.29,52.88 72.25,52.84 72.21,52.82 71.94,52.82 71.78,52.99 71.78,53.94 72.32,54.49
GND on BOTTOM (solid shape): 151.94,32.27 151.94,31.43 151.94,31.43 151.94,30.91 152.12,30.73 152.12,30.51 152.24,30.39 153.21,30.39 153.3,30.25 153.21,30.11 152.27,30.11 152.12,29.96 152.12,29.01 152.24,28.89 153.21,28.89 153.3,28.75 153.21,28.61 152.31,28.61 152.18,28.48 152.18,27.5 152.29,27.39 153.21,27.39 153.3,27.25 153.21,27.11 152.14,27.11 151.88,27.37 151.88,28.12 151.85,28.14 151.77,28.22 151.59,28.22 151.55,28.2 151.53,28.2 151.3,28.16 151.14,27.98 150.56,27.98 150.48,28.06 150.48,31.64 150.65,31.81 150.65,32.04 151.22,32.6 151.6,32.6
GND on BOTTOM (solid shape): 107.71,54.49 107.73,54.48 107.75,54.46 107.89,54.34 108.08,54.31 108.1,54.31 108.12,54.3 108.18,54.23 108.18,54.22 108.26,54.08 108.4,54 108.41,54 108.65,53.77 108.65,53.38 108.64,53.36 108.63,53.34 108.56,53.27 108.52,53.19 108.44,53.17 108.37,53.22 108.3,53.32 108.21,53.39 107.87,53.38 107.69,53.09 107.69,53.07 107.55,52.94 107.5,52.91 107.46,52.88 107.43,52.84 107.39,52.82 107.12,52.82 106.96,52.99 106.96,53.94 107.34,54.33 107.36,54.33 107.48,54.37 107.58,54.46 107.58,54.47 107.62,54.49
GND on BOTTOM (solid shape): 225.75,29.08 226.17,29.08 227.29,29.08 227.32,29.06 227.33,29.03 227.33,28.87 227.32,28.84 227.28,28.82 226.17,28.82 226.17,28.58 227.28,28.58 227.32,28.56 227.33,28.53 227.33,28.37 227.32,28.34 227.28,28.32 226.17,28.32 226.17,28.08 227.28,28.08 227.32,28.06 227.33,28.03 227.33,27.87 227.32,27.84 227.28,27.82 226.17,27.82 226.17,27.79 226.16,27.76 226.12,27.74 226.08,27.74 226.05,27.77 226.05,27.79 225.7,28.13 225.33,27.81 225.33,27.79 225.28,27.74 224.57,27.74 224.17,28.15 224.13,28.17 223.99,28.31 223.66,28.62 223.66,29.06 223.66,29.62 223.66,29.62 225.21,29.62
GND on BOTTOM (solid shape): 218.22,19.51 218.4,19.51 218.5,19.41 218.5,17.5 218.52,17.5 218.52,17.22 218.5,17.2 218.45,17.18 218.4,17.16 218.31,17.08 218.28,17.07 218.25,17.06 218.22,17.06 218.19,17.08 218.16,17.1 218.12,17.13 218.07,17.16 218.02,17.17 217.97,17.18 217.92,17.18 217.87,17.18 217.82,17.16 217.77,17.14 217.73,17.12 217.69,17.08 217.65,17.04 217.62,17 217.6,16.95 217.59,16.9 217.58,16.85 217.58,16.8 217.59,16.75 217.6,16.7 217.62,16.66 217.62,16.63 217.62,16.6 217.61,16.58 217.59,16.55 217.56,16.54 217.54,16.53 217.52,16.53 216.96,16.53 216.76,16.74 216.76,17 217.16,17.4 217.61,17.4 217.61,17.48 217.63,17.49 218.2,17.5 218.2,18.8 218,18.8 218,17.5 217.7,17.5 217.7,18.8 217.68,18.86 217.7,18.89 217.87,19.06 217.87,19.51 217.65,19.73 216.53,19.73 216.51,19.73 216.48,19.73 216.45,19.75 216.43,19.77 216.41,19.79 216.4,19.82 216.4,19.85 216.4,19.88 216.41,19.91 216.43,19.94 216.45,19.96 216.48,19.97 216.51,19.98 216.53,19.98 217.76,19.98
GND on BOTTOM (solid shape): 101.06,93.2 101.14,93.23 101.21,93.2 101.31,93.11 101.44,93.07 101.51,93.03 101.53,92.95 101.56,92.76 101.71,92.65 101.77,92.6 101.78,92.52 101.77,92.43 101.78,92.34 101.78,92.32 101.78,92.3 101.63,92.15 101.55,92.05 101.52,91.92 101.5,91.84 101.42,91.8 101.26,91.77 101.13,91.67 101.05,91.63 100.97,91.67 100.89,91.74 100.8,91.79 100.73,91.86 100.75,91.96 100.79,91.99 100.79,92.07 100.8,92.1 100.82,92.1 101.02,92.36 100.93,92.67 100.93,93.07
GND on BOTTOM (solid shape): outline of 107 points within 65.06,87.83 70.79,92.05
GND on BOTTOM (solid shape): 32.67,30.69 32.67,30.32 32.64,30.25 32.57,30.22 32.44,30.19 32.33,30.11 32.26,30.09 32.19,30.11 31.54,29.84 32.19,29.56 32.26,29.59 32.33,29.56 32.44,29.48 32.57,29.45 32.64,29.42 32.67,29.35 32.67,29.06 32.43,28.82 30.09,28.82 29.91,29 29.91,29.48 29.95,29.56 30.03,29.58 30.49,29.86 30.22,30.32 30.2,30.32 30.18,30.35 30.18,30.4 30.2,30.48 30.23,30.52 30.23,31.78 30.24,31.79 31.04,31.79 31.13,31.88 31.47,31.88
GND on BOTTOM (solid shape): 11.12,61.98 11.12,61.44 11.44,59.27 9.6,58.09 2.02,58.09 2.02,55.57 11.26,55.57 12.48,55.97 13.69,55.51 15.63,55.51 16.05,55.08 16.05,53.89 15.94,53.78 14.64,53.78 14.35,53.49 14.35,53.01 14.13,52.78 13.65,52.78 13.65,54.59 13.6,54.64 13.12,54.64 12.38,54.96 11.68,54.56 1.01,54.56 1.01,59.1 9.6,59.1 10.52,59.7 10.35,60.79 10.35,62.11 11,62.11
GND on BOTTOM (solid shape): 78.08,96.94 78.08,96.75 77.99,96.51 78.08,96.27 78.08,96.26 77.6,95.78 77.6,95.67 77.67,95.6 77.68,95.59 77.83,95.45 78.03,95.47 78.04,95.47 78.54,95.47 78.59,95.53 78.67,95.59 78.74,95.68 78.77,95.76 78.78,95.86 78.8,95.92 78.86,95.96 79.05,96.15 78.97,96.4 78.96,96.42 78.96,96.44 78.96,96.49 79.29,96.82 79.33,96.82 79.35,96.81 79.35,96.8 79.6,96.73 79.78,96.92 79.78,96.93 79.81,96.96 80.07,96.96 80.29,96.74 80.29,96.23 80.22,96.16 80.2,96.16 79.96,96.05 79.86,95.81 79.86,95.79 79.83,95.77 79.81,95.75 79.79,95.75 79.59,95.68 79.51,95.48 79.5,95.45 79.44,95.39 79.22,95.39 79.21,95.4 78.98,95.41 78.78,95.27 78.77,95.25 78.74,95.24 78.72,95.24 78.54,95.06 77.06,95.06 76.68,94.68 76.48,94.68 76.4,94.76 76.4,94.88 76.52,94.99 76.52,95.05 77.09,95.62 77.09,95.83 77.09,95.85 77.11,95.88 77.67,96.44 77.67,96.94 77.68,97 77.78,97.1 77.93,97.1
GND on BOTTOM (solid shape): outline of 86 points within 76.81,84.27 80.92,86.02
GND on BOTTOM (solid shape): outline of 197 points within 42.81,104.41 48.47,114.26
GND on BOTTOM (solid shape): outline of 183 points within 222.73,31.7 234.22,37.32
GND on BOTTOM (solid shape): outline of 257 points within 140.31,19.46 155.27,29.15
GND on BOTTOM (solid shape): outline of 96 points within 102.37,74.17 111.38,78.08
GND on BOTTOM (solid shape): 13.92,96.18 13.92,94.74 13.42,93.52 12.2,93.02 9.44,93.02 8.82,92.15 7.8,91.82 6,91.82 4.98,92.15 4.36,93.02 3.68,93.02 3.76,92.71 3.78,92.4 3.78,91.2 3.28,89.87 2.02,89.19 2.02,83.48 3.36,82.14 5.84,82.14 5.85,82.09 6.42,81.44 7.23,81.75 7.93,81.75 10.59,84.41 14.74,84.41 17.27,81.88 17.27,77.54 14.68,74.95 13.49,74.95 11.72,73.18 11.12,73.18 10.92,72.97 10.37,72.97 10.37,73.87 10.51,74.94 9.6,75.52 1.01,75.52 1.01,76.99 2.33,76.99 3.04,77.29 3.34,78 3.34,79.82 3.04,80.52 2.33,80.81 1.01,80.81 1.01,90.19 1.76,90.19 2.47,90.49 2.76,91.2 2.76,92.4 2.47,93.11 1.76,93.41 1.56,93.41 1.56,94.03 5.29,94.03 5.29,93.54 5.5,93.04 6,92.83 7.8,92.83 8.3,93.04 8.51,93.54 8.51,94.03 12.2,94.03 12.7,94.24 12.91,94.74 12.91,96.33 13.07,96.49 13.61,96.49
GND on BOTTOM (solid shape): outline of 298 points within 134.63,19.46 141.72,32.44
GND on BOTTOM (solid shape): outline of 405 points within 100.48,92.78 106.06,97.1
GND on BOTTOM (solid shape): outline of 475 points within 224.62,14.5 233.11,25.61
GND on BOTTOM (solid shape): outline of 938 points within 91.44,76.43 102.48,82.52
GND on BOTTOM (solid shape): outline of 1431 points within 0.51,0.51 239.29,141.29
GND on BOTTOM (solid shape): outline of 1877 points within 96.32,81.36 105.66,89.39
GND on BOTTOM (solid shape): outline of 2037 points within 77.25,75.3 87.96,89.9
GND on BOTTOM (solid shape): outline of 3541 points within 76.8,81.21 103.17,98.87
GND on SGND (solid shape): outline of 3871 points within 0.51,0.51 239.29,141.29
GND on IN1 (solid shape): 30.39,37.52 30.39,33.47 30.24,33.32 26.08,33.32 26.05,33.35 26.05,37.56 26.2,37.71 30.2,37.71
GND on IN1 (solid shape): 31.48,67.01 31.48,63.58 31.36,63.45 28.05,63.45 27.93,63.58 27.93,67.01 28.05,67.14 31.36,67.14
GND on IN1 (solid shape): 104.38,28.34 104.38,26.82 104.33,26.76 102.67,26.76 102.61,26.82 102.61,28.32 102.76,28.47 104.25,28.47
GND on IN1 (solid shape): 115.95,125.02 115.95,121.56 115.88,121.49 112.43,121.49 112.38,121.54 112.38,125.02 112.44,125.09 115.89,125.09
GND on IN1 (solid shape): 128.68,108.44 128.68,106.14 128.53,105.99 127.19,105.99 127.06,106.13 127.06,108.43 127.18,108.54 128.58,108.54
GND on IN1 (solid shape): 128.91,132.78 128.91,131.78 128.78,131.65 127.75,131.65 127.64,131.76 127.64,132.8 127.79,132.95 128.75,132.95
GND on IN1 (solid shape): 143.03,82.39 143.03,81.37 142.92,81.27 141.87,81.27 141.73,81.41 141.73,82.4 141.85,82.52 142.9,82.52
GND on IN1 (solid shape): 159.75,35.94 159.75,32.74 159.59,32.58 156.29,32.58 156.2,32.66 156.2,35.94 156.43,36.17 159.52,36.17
GND on IN1 (solid shape): 124.48,38.87 124.48,36.02 123.96,35.5 123.96,35.02 123.75,34.81 121.37,34.81 120.22,35.95 120.22,38.75 120.57,39.09 124.26,39.09
GND on IN1 (solid shape): 206.56,38.68 206.56,36.85 206.47,36.76 204.54,36.76 204.41,36.89 204.4,36.91 204.39,36.93 204.39,38.69 204.63,38.93 206.31,38.93
GND on IN1 (solid shape): 30.31,43.99 30.31,41.11 29.53,40.32 26.49,40.32 25.36,41.45 25.36,44.15 25.84,44.63 29.67,44.63
GND on IN1 (solid shape): 102.61,109.41 102.61,106.11 101.6,105.1 100.66,105.1 100.63,105.1 100.61,105.13 100.29,105.33 99.97,105.13 99.95,105.1 99.92,105.1 99.82,105.1 99.8,105.1 99.78,105.13 99.45,105.33 99.13,105.13 99.11,105.1 99.09,105.1 98.74,105.1 97.5,106.34 97.5,110.12 97.6,110.22 97.61,110.23 97.63,110.24 101.79,110.24
GND on IN1 (solid shape): outline of 95 points within 199.69,24.75 209.01,30.59
GND on IN1 (solid shape): outline of 103 points within 65.06,87.8 70.79,91.98
GND on IN1 (solid shape): 11.12,62.02 11.12,61.44 11.44,59.27 9.6,58.09 2.02,58.09 2.02,55.57 11.26,55.57 12.54,55.97 13.78,55.42 15.69,55.42 16.29,54.82 16.29,53.98 16.01,53.7 14.67,53.7 14.35,53.39 14.35,52.99 14.16,52.8 13.85,52.8 13.68,52.97 13.68,54.53 13.58,54.64 13.12,54.64 12.38,54.96 11.68,54.56 1.01,54.56 1.01,59.1 9.6,59.1 10.52,59.71 10.34,60.8 10.34,62.01 10.45,62.12 11.02,62.12
GND on IN1 (solid shape): 13.92,96.35 13.92,94.74 13.42,93.52 12.2,93.02 9.44,93.02 8.82,92.15 7.8,91.82 6,91.82 4.98,92.15 4.36,93.02 3.68,93.02 3.76,92.71 3.78,92.4 3.78,91.2 3.28,89.87 2.02,89.19 2.02,83.8 3.26,82.56 5.11,82.56 5.67,82 5.87,82 5.93,81.82 6.04,81.66 6.6,81.41 7.16,81.67 7.27,81.82 7.33,82 8.17,82 10.57,84.4 14.39,84.4 17.43,81.36 17.43,77.41 15.11,75.09 13.51,75.09 11.6,73.18 10.35,73.18 10.35,73.84 10.52,74.92 9.6,75.52 1.01,75.52 1.01,76.99 2.33,76.99 3.04,77.29 3.34,78 3.34,79.82 3.04,80.52 2.33,80.81 1.01,80.81 1.01,90.19 1.76,90.19 2.47,90.49 2.76,91.2 2.76,92.4 2.47,93.11 1.76,93.41 1.6,93.41 1.54,93.48 1.54,93.96 1.61,94.03 5.29,94.03 5.29,93.54 5.5,93.04 6,92.83 7.8,92.83 8.3,93.04 8.51,93.54 8.51,94.03 12.2,94.03 12.7,94.24 12.91,94.74 12.91,96.35 13.1,96.55 13.73,96.55
GND on IN1 (solid shape): outline of 1398 points within 0.51,0.51 239.29,141.29
GND on SVCC (solid shape): 204.86,30.61 207.98,30.61 209.03,29.57 209.03,28.69 208.59,28.25 206.08,28.25 205.88,28.15 205.84,27.93 205.8,27.89 204.46,27.89 204.43,27.89 204.4,27.88 204.18,27.84 204.07,27.64 204.07,24.47 199.76,24.47 199.66,24.45 199.58,24.39 199.38,24.19 199.2,24.37 199.12,24.42 199.01,24.44 198.36,24.44 198.26,24.55 198.26,29.47 199.08,30.28 202.37,30.28 202.47,30.3 202.55,30.35 202.55,29.16 202.56,29.11 202.59,29.07 202.84,28.82 202.88,28.79 202.93,28.78 203.69,28.78 203.75,28.79 203.79,28.82 203.98,29.02 204.01,29.06 204.02,29.11 204.02,30.1 204.18,30.26 204.43,30.26 204.48,30.27 204.52,30.3 204.84,30.61
GND on SVCC (solid shape): outline of 496 points within 45.91,40.62 127.39,87.97
GND on SVCC (solid shape): outline of 2442 points within 2.03,2.03 237.77,139.77
GND on IN2 (solid shape): 30.39,37.5 30.39,33.56 30.19,33.35 26.09,33.35 25.96,33.48 25.96,37.53 26.14,37.71 30.19,37.71
GND on IN2 (solid shape): 31.48,67.01 31.48,63.58 31.36,63.45 28.05,63.45 27.93,63.58 27.93,67.01 28.05,67.14 31.36,67.14
GND on IN2 (solid shape): 104.35,28.37 104.35,26.89 104.25,26.78 102.77,26.78 102.61,26.94 102.61,28.3 102.79,28.49 104.24,28.49
GND on IN2 (solid shape): 115.95,125.02 115.95,121.56 115.88,121.49 112.43,121.49 112.38,121.54 112.38,125.02 112.44,125.09 115.89,125.09
GND on IN2 (solid shape): 118.52,32.85 118.52,29.01 118.36,28.85 114.62,28.85 114.41,29.06 114.41,32.83 114.6,33.02 118.36,33.02
GND on IN2 (solid shape): 124.54,38.84 124.54,35.59 124.04,35.1 121.07,35.1 120.22,35.95 120.22,38.64 120.68,39.09 124.29,39.09
GND on IN2 (solid shape): 128.66,108.42 128.66,106.02 128.59,105.96 127.2,105.96 127.07,106.08 127.07,108.44 127.18,108.54 128.53,108.54
GND on IN2 (solid shape): 128.91,132.8 128.91,131.77 128.78,131.64 127.76,131.64 127.61,131.79 127.61,132.82 127.78,132.98 128.73,132.98
GND on IN2 (solid shape): 143.03,82.41 143.03,81.3 142.91,81.19 141.84,81.19 141.65,81.37 141.65,82.41 141.84,82.6 142.84,82.6
GND on IN2 (solid shape): 159.67,36 159.67,32.76 159.55,32.64 156.32,32.64 156.14,32.83 156.14,36 156.26,36.11 159.56,36.11
GND on IN2 (solid shape): 206.62,38.73 206.62,36.89 206.43,36.7 204.54,36.7 204.33,36.92 204.33,38.71 204.57,38.96 206.39,38.96
GND on IN2 (solid shape): 30.29,44.01 30.29,41.08 29.53,40.32 26.49,40.32 25.36,41.45 25.36,44.33 25.66,44.63 29.67,44.63
GND on IN2 (solid shape): 200.92,26.65 203.67,26.65 203.86,26.83 203.9,26.83 203.95,26.79 203.95,25.12 203.78,24.95 199.96,24.95 199.91,25.01 199.91,26.72 200.02,26.83 200.73,26.83
GND on IN2 (solid shape): 102.61,110.01 102.61,106.87 100.84,105.1 100.69,105.1 100.66,105.11 100.64,105.13 100.29,105.36 99.94,105.13 99.92,105.11 99.89,105.1 99.85,105.1 99.82,105.11 99.8,105.13 99.45,105.36 99.1,105.13 99.09,105.11 99.06,105.1 98.74,105.1 98.07,105.77 98.07,105.79 97.53,106.34 97.53,110.11 97.95,110.53 102.1,110.53
GND on IN2 (solid shape): outline of 101 points within 65.06,87.8 70.79,92.26
GND on IN2 (solid shape): 11.12,62.01 11.12,61.44 11.44,59.27 9.6,58.09 2.02,58.09 2.02,55.57 11.26,55.57 11.99,55.92 12.81,55.94 15.53,55.94 16.34,55.12 16.34,54.01 15.96,53.62 14.95,53.62 14.11,52.78 13.83,52.78 13.68,52.93 13.68,54.54 13.6,54.62 13.14,54.62 12.39,54.96 11.68,54.56 1.01,54.56 1.01,59.1 9.6,59.1 10.51,59.68 10.37,60.76 10.37,62.09 10.5,62.21 10.92,62.21
GND on IN2 (solid shape): 13.92,96.28 13.92,94.74 13.42,93.52 12.2,93.02 9.44,93.02 8.82,92.15 7.8,91.82 6,91.82 4.98,92.15 4.36,93.02 3.68,93.02 3.76,92.71 3.78,92.4 3.78,91.2 3.28,89.87 2.02,89.19 2.02,84.18 3.69,82.52 5.6,82.52 5.85,82.28 5.84,82.17 6.47,81.43 7.31,81.91 8.28,81.91 10.69,84.33 14.69,84.33 17.41,81.61 17.41,76.89 13.52,73 10.4,73 10.33,73.08 10.33,73.81 10.53,74.91 9.6,75.52 1.01,75.52 1.01,76.99 2.33,76.99 3.04,77.29 3.34,78 3.34,79.82 3.04,80.52 2.33,80.81 1.01,80.81 1.01,90.19 1.76,90.19 2.47,90.49 2.76,91.2 2.76,92.4 2.47,93.11 1.76,93.41 1.61,93.41 1.61,94.03 5.29,94.03 5.29,93.54 5.5,93.04 6,92.83 7.8,92.83 8.3,93.04 8.51,93.54 8.51,94.03 12.2,94.03 12.7,94.24 12.91,94.74 12.91,96.28 13.15,96.53 13.68,96.53
GND on IN2 (solid shape): outline of 1422 points within 0.51,0.51 239.29,141.29
GND on IN3 (solid shape): 30.39,37.59 30.39,33.5 30.21,33.32 26.18,33.32 25.99,33.52 25.99,37.66 26.09,37.76 30.21,37.76
GND on IN3 (solid shape): 31.48,67.01 31.48,63.58 31.36,63.45 28.05,63.45 27.93,63.58 27.93,67.01 28.05,67.14 31.36,67.14
GND on IN3 (solid shape): 104.38,28.33 104.38,26.92 104.25,26.78 102.78,26.78 102.67,26.9 102.67,28.35 102.83,28.52 104.2,28.52
GND on IN3 (solid shape): 115.95,125.02 115.95,121.56 115.88,121.49 112.43,121.49 112.38,121.54 112.38,125.02 112.44,125.09 115.89,125.09
GND on IN3 (solid shape): 128.72,108.4 128.72,106.18 128.49,105.96 127.26,105.96 127.08,106.14 127.08,108.39 127.23,108.54 128.57,108.54
GND on IN3 (solid shape): 128.92,132.77 128.92,131.78 128.79,131.65 127.66,131.65 127.6,131.71 127.6,132.77 127.77,132.93 128.76,132.93
GND on IN3 (solid shape): 143.04,82.37 143.04,81.37 142.86,81.2 141.88,81.2 141.69,81.39 141.69,82.38 141.87,82.56 142.85,82.56
GND on IN3 (solid shape): 203.92,27.49 203.92,25.05 203.81,24.95 200.03,24.95 199.9,25.08 199.9,27.81 200.1,28.02 203.39,28.02
GND on IN3 (solid shape): 30.29,44.01 30.29,41.08 29.53,40.32 26.19,40.32 25.36,41.15 25.36,44.33 25.66,44.63 29.67,44.63
GND on IN3 (solid shape): 124.44,38.7 124.44,35.78 124.28,35.63 123.77,35.63 123.59,35.45 120.71,35.45 120.23,35.94 120.23,38.87 120.24,38.89 120.25,38.91 120.4,39.06 124.07,39.06
GND on IN3 (solid shape): 102.52,110.15 102.52,105.96 101.66,105.1 100.89,105.1 100.86,105.11 100.84,105.13 100.45,105.52 99.91,105.4 99.87,105.38 99.84,105.4 99.3,105.52 98.9,105.13 98.9,105.12 98.87,105.1 98.74,105.1 97.64,106.19 97.64,109.87 98.35,110.58 102.1,110.58
GND on IN3 (solid shape): 67.92,91.9 67.92,91.43 68.04,91.31 68.62,91.31 68.98,90.95 69.97,90.95 70.79,90.13 70.79,89.68 70.5,89.68 70.2,89.98 70.21,90 69.72,90.41 69.67,89.78 69.72,89.69 69.67,89.61 69.53,89.17 69.94,88.96 69.97,88.96 70.11,88.82 70.14,88.82 70.19,88.78 70.17,88.73 70.11,88.67 70.09,88.64 69.88,88.43 68.16,88.43 67.52,87.8 65.42,87.8 65.32,87.9 65.31,87.9 65.18,88.02 65.33,88.17 65.33,91.77 65.43,91.86 66.85,91.86 67.24,92.26 67.56,92.26
GND on IN3 (solid shape): 11.12,61.98 11.12,61.44 11.44,59.27 9.6,58.09 2.02,58.09 2.02,55.57 11.26,55.57 12.28,55.97 13.36,55.73 15.45,55.73 15.73,55.45 15.73,53.98 15.43,53.68 14.57,53.68 14.35,53.46 14.35,52.98 14.14,52.77 13.75,52.77 13.75,54.51 13.65,54.62 13.14,54.62 12.39,54.96 11.68,54.56 1.01,54.56 1.01,59.1 9.6,59.1 10.51,59.68 10.38,60.75 10.38,62.03 10.56,62.21 10.9,62.21
GND on IN3 (solid shape): 13.92,96.24 13.92,94.74 13.42,93.52 12.2,93.02 9.44,93.02 8.82,92.15 7.8,91.82 6,91.82 4.98,92.15 4.36,93.02 3.68,93.02 3.76,92.71 3.78,92.4 3.78,91.2 3.28,89.87 2.02,89.19 2.02,83.94 3.84,82.12 5.84,82.12 5.85,82.08 5.87,81.98 5.9,81.89 6.51,81.42 7.21,81.73 8.08,81.73 10.42,84.07 11.07,84.07 11.44,84.44 14.45,84.44 17.02,81.86 17.02,77.5 14.53,75.01 13.34,75.01 11.5,73.18 10.99,73.18 10.82,73 10.4,73 10.34,73.07 10.34,73.82 10.52,74.91 9.6,75.52 1.01,75.52 1.01,76.99 2.33,76.99 3.04,77.29 3.34,78 3.34,79.82 3.04,80.52 2.33,80.81 1.01,80.81 1.01,90.19 1.76,90.19 2.47,90.49 2.76,91.2 2.76,92.4 2.47,93.11 1.76,93.41 1.6,93.41 1.56,93.45 1.56,94.01 1.59,94.03 5.29,94.03 5.29,93.54 5.5,93.04 6,92.83 7.8,92.83 8.3,93.04 8.51,93.54 8.51,94.03 12.2,94.03 12.7,94.24 12.91,94.74 12.91,96.43 12.99,96.51 13.65,96.51
GND on IN3 (solid shape): outline of 1422 points within 0.51,0.51 239.29,141.29
GND on SGND1 (solid shape): outline of 3915 points within 0.51,0.51 239.29,141.29
VCC1.2O on BOTTOM (solid shape): 114.35,28.32 114.35,26.99 113.47,26.12 110.27,26.12 110.06,26.32 110.06,27.47 110.23,27.64 113.33,27.64 114.1,28.4 114.26,28.4
VCC_XD on TOP (solid shape): 26.07,32.92 26.07,31.5 25.7,31.13 25.54,31.13 25.2,30.8 25.2,30.42 24.75,29.96 24.75,24.37 20.64,20.26 20.62,20.26 19.19,19.91 17.9,19.2 17.89,19.19 15.67,19.19 15.11,19.75 15.11,20.85 15.36,21.1 16.43,21.1 17.04,21.72 17.04,22.43 17.29,22.68 19.82,22.68 20.09,22.94 20.09,26.59 25.09,31.59 25.09,32.32 25.76,32.99 26.01,32.99
VDD10 on TOP (solid shape): 36.39,41.7 36.39,39.91 36.28,39.81 35.98,39.81 35.32,40.46 35.07,40.46 35.06,40.47 34.45,40.47 34.33,40.59 34.33,41.25 34.32,41.26 34.32,41.62 34.57,41.86 36.23,41.86
VDD10 on BOTTOM (solid shape): 30.06,31.79 30.09,31.77 30.11,31.74 30.11,30.57 30.03,30.5 29.41,30.5 29.33,30.54 29.31,30.62 29.25,30.95 28.95,31.1 28.91,31.12 28.9,31.16 28.9,31.73 28.96,31.79
VDD10 on BOTTOM (solid shape): outline of 1256 points within 18.31,32.92 38.34,42.22
VDD10 on IN3 (solid shape): outline of 113 points within 26.94,30.66 33.33,37.88
1P35V_BOOT on BOTTOM (solid shape): 101.42,27.72 102.39,27.72 102.43,27.68 102.43,27.54 102.4,27.51 101.42,27.51 101.42,27.51 100.59,27.51 100.37,27.29 100.37,26.73 100.25,26.61 99.51,26.61 99.44,26.68 99.44,27.63 99.54,27.73 101.42,27.73
1P35V_LGATE on BOTTOM (solid shape): 94.97,22.91 94.97,21.88 94.6,21.52 93.74,21.52 93.57,21.69 93.57,22.76 93.77,22.96 94.91,22.96
1P35V_LGATE on BOTTOM (solid shape): 102.76,26.52 102.78,26.51 102.8,26.5 102.82,26.48 102.82,25.52 102.83,25.52 102.83,25.43 102.81,25.39 102.8,25.38 102.73,25.28 102.69,25.16 102.7,25.05 102.73,24.94 102.74,24.91 102.72,24.88 102.58,24.74 102.01,24.74 101.8,24.95 101.8,26.15 102.15,26.5 102.67,26.5 102.68,26.52
1P35V_PHASE on BOTTOM (solid shape): 94.61,28.48 94.61,26.39 95.06,25.94 97.21,25.94 98.08,25.07 99.04,25.07 99.37,25.41 99.37,26.16 99.47,26.26 100.91,26.26 101.42,26.77 101.42,26.9 101.43,26.92 102.38,26.92 102.4,26.89 102.4,26.78 102.33,26.7 102.01,26.7 101.64,26.34 101.64,25.44 101.64,25.43 101.64,24.49 100.56,23.41 91.18,23.41 90.5,24.09 90.5,28.17 90.89,28.55 94.54,28.55
1P35V_UGATE on BOTTOM (solid shape): 94.58,29.67 94.59,29.65 94.6,29.63 94.6,28.86 94.58,28.83 94.56,28.82 94.54,28.82 93.47,28.82 93.19,29.09 93.19,29.61 93.27,29.69 94.55,29.69
1P35V_UGATE on BOTTOM (solid shape): 101.42,27.32 102.39,27.32 102.42,27.29 102.42,27.17 102.38,27.13 102.36,27.12 102.34,27.11 101.42,27.11 101.42,27.1 101.19,27.1 101.14,27.05 101.14,26.77 100.99,26.62 100.59,26.62 100.51,26.71 100.51,27.13 100.63,27.26 100.97,27.26 100.97,27.26 101.05,27.26 101.12,27.32 101.42,27.32
8068LX_1.05V on BOTTOM (solid shape): 126.68,107.4 126.73,107.35 126.73,107.19 126.72,107.16 126.68,107.14 126.02,107.14 126.02,106.9 126.68,106.9 126.72,106.88 126.73,106.85 126.73,106.69 126.72,106.66 126.68,106.64 126.02,106.64 126.02,106.4 126.68,106.4 126.72,106.38 126.73,106.35 126.73,104.63 126.58,104.48 125.92,104.48 125.41,103.97 125.41,102.24 126.43,101.22 126.43,100.69 126.27,100.54 122.33,100.54 121.59,101.28 121.59,107.06 121.92,107.4 126.02,107.4
8068SVIN_1.05V on BOTTOM (solid shape): 131.05,108.11 131.05,107.42 131.02,107.4 131.02,107.32 131.25,107.09 131.25,106.3 131.2,106.25 130.44,106.25 130.34,106.35 130.34,107.09 130.29,107.14 129.73,107.14 129.07,107.14 129.04,107.17 129.04,107.34 129.06,107.38 129.09,107.4 129.73,107.4 130.19,107.4 130.34,107.5 130.34,108.21 130.38,108.28 130.39,108.3 130.42,108.31 130.85,108.31
24707_LX on TOP (solid shape): 54.99,22.08 54.99,21.46 54.65,21.13 54.65,20.34 54.44,20.13 53.33,20.13 53.11,20.36 53.11,21.97 53.44,22.3 54.77,22.3
24707_LX on TOP (solid shape): 47.92,21.18 47.92,20.45 47.83,20.35 44.51,20.35 44.48,20.38 44.48,20.54 44.55,20.61 45.34,20.61 45.34,20.62 45.81,20.62 46.64,21.44 47.66,21.44
24707_LX on BOTTOM (solid shape): 58.61,24.26 58.61,18.97 58.01,18.37 50.41,18.37 49.9,18.88 49.9,20.66 50.15,20.91 50.79,20.91 51.02,21.14 51.02,21.89 51.19,22.06 53.64,22.06 54.95,23.38 54.95,24.19 55.1,24.34 58.53,24.34
24737_DH on TOP (solid shape): 46.66,20.06 46.66,19.79 46.45,19.58 46.15,19.58 45.9,19.82 45.34,19.82 45.34,19.83 44.52,19.83 44.49,19.87 44.49,19.87 44.49,20.04 44.56,20.11 45.34,20.11 45.37,20.14 46.58,20.14
24737_DH on BOTTOM (solid shape): 50.76,21.93 50.76,21.12 50.72,21.07 50.7,21.05 50.68,21.05 50.63,21.05 50.09,21.05 49.93,21.05 49.27,21.05 49.14,21.19 49.14,22.13 49.26,22.26 50.43,22.26
24737_DL on TOP (solid shape): 44.35,18.62 44.35,18.42 44.38,18.39 44.77,18.39 45.08,18.08 45.08,17.35 45.07,17.32 45.03,17.3 44.57,17.3 44.06,17.82 44.06,18.64 44.06,18.66 44.09,18.69 44.28,18.69
24737_DL on BOTTOM (solid shape): 50.76,18.01 50.76,16.82 50.56,16.63 49.81,16.63 49.52,16.91 49.52,17.89 49.66,18.03 50.74,18.03
24737_REGN on TOP (solid shape): 45.65,19.12 45.65,18.94 45.75,18.85 46.03,18.85 46.65,18.23 46.66,18.21 46.67,18.19 46.67,17.49 46.43,17.25 45.47,17.25 45.3,17.41 45.3,18.31 44.81,18.79 44.56,18.79 44.49,18.86 44.49,19.06 44.5,19.1 44.54,19.11 45.34,19.11 45.37,19.13 45.63,19.13
24737_REGN on BOTTOM (solid shape): 46.71,18.81 46.71,17.3 46.64,17.23 45.46,17.23 45.29,17.41 45.29,18.69 45.49,18.89 46.62,18.89
24737_VCC on TOP (solid shape): 48.85,24.96 48.85,23.52 48.42,23.09 48.03,23.09 47.77,22.82 47.77,22.82 47.77,21.92 47.7,21.85 46.73,21.85 45.69,20.81 45.37,20.81 45.34,20.83 44.57,20.83 44.51,20.89 44.5,20.91 44.5,20.92 44.5,21.1 44.58,21.18 44.87,21.18 46.63,22.94 46.63,22.94 46.82,23.12 46.82,24.77 47.06,25.01 48.79,25.01
61087SW on TOP (solid shape): 52.17,125.38 52.21,125.36 52.22,125.33 52.22,124.52 52.45,124.52 52.45,125.33 52.46,125.36 52.5,125.38 52.67,125.38 52.71,125.36 52.72,125.33 52.72,124.52 52.74,124.5 52.75,124.48 52.75,124.16 52.49,123.91 52.49,119.22 52.26,119 52.26,116.56 51.82,116.11 50.58,116.11 50.23,116.46 50.23,125.33 50.25,125.36 50.28,125.38
+601_VCC on TOP (solid shape): 203.58,41.05 203.61,41.06 203.64,41.04 204.3,40.38 204.31,40.38 204.35,40.34 204.54,40.34 204.6,40.28 204.61,40.26 204.61,40.24 204.61,39.23 204.59,39.2 204.56,39.19 204.01,39.19 203.8,39.4 202.26,39.4 202.2,39.46 202.11,39.54 202.01,39.59 201.79,39.63 201.57,39.59 201.53,39.58 201.51,39.6 201.49,39.62 201.49,40.67 201.77,40.95 202.45,40.95 202.47,40.96 203.33,40.96
+601_VCC on TOP (solid shape): 206.91,36.43 206.93,36.42 206.95,36.41 207.1,36.3 207.28,36.24 207.29,36.23 208.25,35.28 208.48,35.28 208.71,35.05 209.37,35.05 209.48,35.06 209.59,35.09 209.67,35.13 209.77,35.19 209.81,35.18 210.17,35.05 210.56,35.19 210.59,35.18 210.72,35.1 210.85,35.06 210.91,35.05 211,35.05 211.14,34.9 211.14,34.71 211.14,34.71 211.14,33.86 210.91,33.62 209.01,33.62 208.62,34.02 208.29,34.02 208.29,34.02 207.43,34.88 207.25,34.88 207.07,35.06 207.05,35.12 207.02,35.17 206.92,35.26 206.8,35.32 206.75,35.33 206.7,35.33 206.58,35.31 206.47,35.25 206.45,35.24 206.42,35.24 206.4,35.25 206.33,35.32 206.31,35.34 206.32,35.37 206.33,35.4 206.33,36.39 206.35,36.42 206.38,36.43
+601_VCC on BOTTOM (solid shape): outline of 353 points within 202.36,30.54 211.28,43.26
+601_VCC on IN1 (solid shape): outline of 402 points within 201.74,34.62 211.08,43.29
+AZA_VDD on TOP (solid shape): 205.48,29.85 205.7,29.75 205.93,29.81 206.27,29.81 206.49,29.6 206.97,29.6 207.02,29.55 207.02,29.09 206.96,29.03 205.8,29.03 205.49,28.72 204.63,28.72 204.61,28.7 204.59,28.7 204.51,28.7 204.47,28.71 204.46,28.75 204.46,29.27 204.79,29.6 204.81,29.6 205.07,29.85
+AZA_VDD on TOP (solid shape): 195.39,32.95 195.39,32.29 194.97,31.87 194.97,30.14 195.11,30 197.27,30 197.6,29.67 198.7,29.67 198.72,29.66 198.73,29.65 199.3,29.09 199.3,28.75 199.29,28.71 199.25,28.7 198.29,28.7 198.29,28.68 198.28,28.65 198.24,28.63 197.6,28.63 197.14,29.09 195.9,29.09 195.71,29.27 194.41,29.27 194.25,29.43 194.17,29.47 194.16,29.56 194.18,29.65 194.2,29.74 194.2,29.85 194.18,29.96 194.14,30.06 194.09,30.15 194.06,30.2 194.01,30.24 193.94,30.32 193.94,30.41 193.33,31.02 193.33,32.31 193.99,32.97 195.36,32.97
+AZA_VDD on IN2 (solid shape): outline of 246 points within 194.6,27.03 206.39,33.1
+SMDDR_VREF_CA_A on TOP (solid shape): outline of 101 points within 60.01,48.85 62.39,50.14
+SMDDR_VREF_CA_A on TOP (solid shape): outline of 109 points within 77.79,48.72 80.38,50.24
+SMDDR_VREF_CA_A on TOP (solid shape): outline of 131 points within 70.73,48.89 73.2,50.79
+SMDDR_VREF_CA_A on BOTTOM (solid shape): outline of 103 points within 53.15,48.8 55.64,50.1
+SMDDR_VREF_CA_A on BOTTOM (solid shape): outline of 113 points within 71.06,48.8 73.54,50.17
+SMDDR_VREF_CA_B on TOP (solid shape): outline of 105 points within 95.19,48.85 97.84,50.25
+SMDDR_VREF_CA_B on TOP (solid shape): outline of 99 points within 112.97,48.72 115.56,50.11
+SMDDR_VREF_CA_B on TOP (solid shape): 107.29,50.48 107.37,50.44 107.39,50.35 107.66,50 107.93,50.35 107.94,50.44 108.03,50.48 108.07,50.48 108.18,50.37 108.18,50.34 108.18,50.33 108.2,50.17 108.31,50.04 108.32,50.04 108.33,50.01 108.33,49.76 108.32,49.73 108.31,49.71 108.27,49.69 108.24,49.65 108.22,49.64 108.2,49.63 108.15,49.63 108.09,49.62 108.04,49.59 108.01,49.55 107.97,49.54 107.93,49.55 107.92,49.57 107.77,49.73 107.55,49.74 107.54,49.73 107.31,49.73 106.71,49.48 107.31,49.22 107.54,49.22 107.55,49.22 107.66,49.2 107.77,49.22 107.87,49.21 107.91,49.13 107.91,49.04 107.98,48.97 107.99,48.92 107.95,48.88 107.85,48.88 107.6,48.95 107.4,48.8 107.4,48.79 107.35,48.75 106.66,48.75 106.32,49.09 106.32,49.11 106.05,49.38 106.05,50.06 106.23,50.24 106.49,50.24 106.73,50.48
+SMDDR_VREF_CA_B on BOTTOM (solid shape): outline of 115 points within 106.23,48.8 108.72,50.17
+SMDDR_VREF_CA_B on BOTTOM (solid shape): outline of 124 points within 88.33,48.8 90.82,50.1
+TPVDD on TOP (solid shape): 117.85,20.86 117.85,20.59 117.85,20.52 117.86,20.44 117.86,20.19 118.07,19.98 118.07,19.64 117.91,19.48 116.42,19.48 116.12,19.17 116.12,19.16 116.06,19.1 115.67,19.1 115.66,19.1 115.5,19.2 115.34,19.23 115.07,19.23 115.04,19.25 115.02,19.28 115.02,19.41 115.04,19.42 115.04,19.67 115.47,20.11 116.44,20.11 116.62,20.28 116.62,20.45 117.05,20.88 117.83,20.88
+TPVDD on BOTTOM (solid shape): 116.97,21.31 116.97,19.64 116.83,19.49 116.81,19.49 116.48,19.15 114.68,17.35 110.53,17.35 110.26,17.63 110.26,19.13 110.33,19.21 110.38,19.27 110.42,19.34 110.58,19.34 110.68,19.19 110.83,19.1 110.84,19.09 111.21,18.72 112.84,18.72 113.57,19.46 113.57,20.03 113.67,20.12 115.51,20.12 115.54,20.15 115.54,21.61 116.67,21.61
+TYPEC_VBUS on TOP (solid shape): 14.9,86.18 15.08,85.9 15.41,85.88 15.58,85.88 15.73,85.73 15.73,85.45 15.6,85.32 14.27,85.32 14.02,85.56 14.02,86.13 14.12,86.23 14.9,86.23
+TYPEC_VBUS on TOP (solid shape): 25.05,81.03 24.95,80.86 24.92,80.67 24.92,79.85 25.05,79.72 25.05,79.51 25.05,79.42 25.07,79.34 25.07,79.29 25.07,78.75 25.07,78.37 24.96,78.26 23.29,78.26 22.94,78.61 22.94,79.09 22.11,79.92 22.11,80.98 22.21,81.08 25,81.08
+TYPEC_VBUS on BOTTOM (solid shape): outline of 1157 points within 5.49,77.69 24.64,90.27
+TYPEC_VBUS on IN2 (solid shape): outline of 1406 points within 5.47,77.78 24.85,90.34
+TYPEC_VBUS_C on TOP (solid shape): outline of 236 points within 18.94,81.53 26.75,89.14
+VNN on TOP (solid shape): 82.41,122.32 82.41,118.31 82.01,117.91 79.82,117.91 78.47,119.26 78.47,123.3 79.08,123.91 80.82,123.91
+VNN on TOP (solid shape): 94.08,83.75 94.08,83.25 94.03,83.2 94.03,82.67 94.03,82.65 94.02,82.64 93.9,82.52 93.9,82.03 93.78,81.91 93.41,81.91 93.37,81.92 93.36,81.95 92.95,82.23 92.65,81.84 92.65,81.82 92.64,81.8 92.47,81.63 91.79,81.63 91.66,81.76 91.66,82.11 91.83,82.28 92.43,82.28 92.44,82.28 92.74,82.58 92.74,82.85 92.89,83 93.29,83 93.51,83.22 93.51,83.63 93.68,83.81 94.02,83.81
+VNN on TOP (solid shape): 87.27,86.06 87.54,86.06 87.57,86.09 87.62,86.11 87.65,86.14 87.99,86.14 88.01,86.12 88.13,86.12 88.23,86.1 88.33,86.12 88.42,86.12 88.44,86.09 88.44,84.71 88.37,84.63 87.86,84.63 87.5,84.27 87.01,84.27 86.76,84.01 85.31,84.01 85.09,83.8 85.09,83.17 84.91,82.98 84.18,82.98 83.76,82.56 82.72,82.56 82.57,82.71 82.57,83.48 82.88,83.79 82.96,83.82 83.03,83.77 83.54,83.66 83.61,84.18 83.61,85.03 83.61,85.24 83.72,85.34 84.21,85.34 84.63,85.76 84.63,86.1 84.77,86.24 87.09,86.24
+VNN on BOTTOM (solid shape): 75.14,126.27 75.17,126.26 75.19,126.25 76.03,125.05 76.69,125.05 76.82,124.92 76.82,122.13 77.08,121.87 77.46,121.87 77.84,122.26 77.84,123.5 78.22,123.88 80.38,123.88 80.68,123.58 80.68,122.64 80.78,122.53 82.1,122.53 82.39,122.35 82.4,122.33 82.41,122.3 82.41,118.55 82.13,118.27 81.77,118.27 80.86,117.35 80.86,112.39 81.44,111.81 83.34,111.81 83.45,111.7 83.45,109.36 82.99,108.9 75.21,108.9 74.51,109.59 74.51,118.24 74.41,118.34 72.66,118.34 72.45,118.55 72.45,124.62 72.96,125.13 72.96,126.07 73.16,126.27
+VNN on BOTTOM (solid shape): outline of 103 points within 83.77,83.75 88.09,85.91
+VNN on SVCC (solid shape): outline of 97 points within 63.11,82.25 88,124.54
+VNN on IN2 (solid shape): outline of 5525 points within 73.92,81.97 94.04,122.97
+WL_VDD on TOP (solid shape): 162.77,26.01 162.77,25.63 162.62,25.48 161.17,25.48 161.02,25.63 161.02,27.16 161.12,27.26 161.53,27.26
+WL_VDD on TOP (solid shape): 168.59,30.75 168.59,30.4 168.46,30.28 167.8,30.28 167.27,29.75 166.64,29.75 166.58,29.8 166.58,30.28 167.18,30.88 168.46,30.88
+WL_VDD on TOP (solid shape): 161.86,44.89 161.86,40.57 161.78,40.49 160.26,40.49 159.76,40.99 159.76,45.5 159.95,45.68 161.07,45.68
+WL_VDD on TOP (solid shape): 172.05,34.04 172.05,30.61 170.92,29.48 169.27,29.48 169.1,29.65 169.1,30.04 169.18,30.12 169.74,30.12 170.93,31.3 170.93,33.6 169.4,35.13 169.28,35.13 169.28,35.14 168.01,35.14 168.01,36.31 168.11,36.4 169.68,36.4
+WL_VDD on BOTTOM (solid shape): outline of 462 points within 159.53,25.51 169.66,46.62
ADOGND on BOTTOM (solid shape): 206.26,32.03 206.26,31.17 206.23,31.15 204.74,31.15 204.56,30.97 204.56,30.74 204.35,30.54 204.05,30.54 203.74,30.23 203.74,29.16 203.64,29.06 203.08,29.06 202.93,29.2 202.93,30.43 203.06,30.56 203.06,31.1 203.06,31.27 202.88,31.45 202.88,31.76 203.01,31.88 203.62,31.88 203.85,31.81 204.08,31.88 205.32,31.88 205.52,32.09 206.21,32.09
ADOGND on SGND (solid shape): outline of 88 points within 199,17.23 213.35,32.97
ADOGND on IN1 (solid shape): outline of 394 points within 202.82,22.04 212.58,32.97
ADOGND on SVCC (solid shape): outline of 92 points within 199,17.23 213.35,32.97
ADOGND on IN2 (solid shape): outline of 1040 points within 199,17.23 213.34,32.97
ADOGND on IN3 (solid shape): 208.31,25.37 208.38,25.47 208.49,25.44 208.56,25.38 208.64,25.33 208.83,25.25 209.03,25.22 209.14,25.22 209.17,25.2 209.17,25.19 209.28,25.04 209.44,24.96 209.47,24.94 209.48,24.91 209.48,21.87 209.4,21.79 209.31,21.76 209.24,21.82 209.2,21.87 209.15,21.95 209.09,22.01 208.5,22.61 208.31,22.79
ADOGND on IN3 (solid shape): outline of 789 points within 199,17.23 213.34,32.97
ADOGND on SGND1 (solid shape): outline of 88 points within 199,17.23 213.35,32.97
BAT-V on TOP (solid shape): 71.08,28.11 71.09,28.09 71.09,28.07 71.09,26.18 71.1,26.13 71.1,26.09 71.13,26.01 71.13,25.65 71.13,19.17 69.16,17.19 67.86,17.19 67.19,16.52 67.17,16.51 67.15,16.51 62.92,16.51 62.82,16.6 62.82,20.08 62.93,20.19 64.22,20.19 64.4,20.38 64.4,25.05 63.89,25.56 63.89,27.88 64.3,28.28 70.9,28.28
BAT-V on BOTTOM (solid shape): 71.14,30.84 71.14,26.35 71.13,26.34 71.09,26.18 71.13,26.01 71.14,26 71.14,18.96 68.76,16.58 66.34,16.58 66.31,16.59 66.29,16.63 66.29,18.37 64.6,18.37 64.42,18.18 64.09,18.18 64.05,18.2 64.04,18.23 64.04,19.38 64.05,19.41 64.07,19.43 65.99,21.19 65.81,23.78 65.81,26.89 65.21,27.49 62.04,27.49 61.56,27.97 60.49,27.97 60.39,28.07 60.39,31.25 60.45,31.31 70.67,31.31
CCD+DMIC_PWR on BOTTOM (solid shape): 62.87,126.28 65.17,126.28 65.3,126.15 65.3,125.56 64.97,125.23 64.75,125.23 64.73,125.23 64.71,125.25 62.51,125.25 62.01,125.74 61.4,125.74 61.31,125.83 61.31,126.52 61.4,126.61 62.53,126.61
G5719LX1.8V on BOTTOM (solid shape): 45.44,77.93 45.44,76.74 45.92,76.26 47.76,76.26 48.09,75.93 48.09,75.01 47.89,74.81 46.04,74.81 45.07,75.77 45.07,76.21 44.46,76.82 44.46,77.83 44.72,78.08 45.29,78.08
G5719LX1.24V on BOTTOM (solid shape): 130.59,85.58 130.59,84.26 131.25,83.6 131.25,83.09 130.64,82.48 130.59,82.48 130.59,81.54 130.45,81.39 129.52,81.39 129.4,81.51 129.4,83.88 129.6,84.08 129.6,85.27 129.98,85.65 130.52,85.65
HDD+M2_PWR on TOP (solid shape): 233.17,32.11 233.18,32.09 233.17,31.95 233.17,31.81 233.17,21.55 233.06,21.44 231.56,21.44 231.46,21.54 231.46,23.24 231.51,23.29 231.51,25.03 231.25,25.28 231.25,25.51 231.27,25.56 231.29,25.6 231.3,25.68 231.31,25.76 231.31,27.18 231.3,27.19 231.27,27.27 231.31,27.34 231.49,27.55 231.55,27.82 231.51,28.01 231.41,28.18 231.39,28.25 231.42,28.32 231.61,28.51 231.61,29.03 231.24,29.41 230.65,29.41 230.58,29.48 230.02,29.48 229.63,29.66 229.32,29.36 229.32,29.32 228.1,29.32 228.05,29.37 228.02,29.45 228.06,29.53 228.12,30.11 227.53,30.06 227.46,30.01 227.38,30.04 227.09,30.33 227.09,32.31 227.19,32.42 232.87,32.42
HDD+M2_PWR on BOTTOM (solid shape): outline of 187 points within 221.3,25.98 233.16,33.13
L_SPK+ on BOTTOM (solid shape): 187.41,22.07 187.41,21.82 187.62,21.62 187.92,21.62 188.13,21.41 188.13,21.09 188.42,20.8 189.05,20.8 190.41,19.44 190.41,17.51 190.36,17.45 189.44,17.45 189.14,17.76 189.14,18.65 186.9,20.89 186.9,22.02 187.03,22.15 187.34,22.15
L_SPK+ on IN1 (solid shape): 202.6,34.31 202.6,33 202.47,32.87 202.47,32.49 202.6,32.36 202.6,31.32 202.5,31.22 201.92,31.22 201.84,31.3 201.84,32.97 201.81,32.99 201.81,33 201.38,33.43 201.38,34.43 201.68,34.73 202.19,34.73
L_SPK+ on IN1 (solid shape): 186.74,23.94 186.77,23.93 186.79,23.89 186.79,23.87 187.53,23.13 187.54,23.02 187.54,22.55 187.55,22.54 187.55,20.94 187.44,20.84 186.56,20.84 185.77,21.63 185.77,23.88 185.83,23.94
L_SPK- on BOTTOM (solid shape): 189.93,21.87 189.93,21.48 191.65,19.75 191.65,17.66 191.5,17.51 191.04,17.51 190.92,17.63 190.92,19.17 189.16,20.93 188.54,20.93 188.33,21.14 188.33,22.08 188.48,22.23 189.57,22.23
L_SPK- on IN1 (solid shape): 189.27,23.3 189.27,21.14 189.06,20.94 188.05,20.94 187.95,21.04 187.95,23.28 188.18,23.5 189.06,23.5
L_SPK- on IN1 (solid shape): 201.74,32.92 201.74,31.04 201.64,30.94 201.18,30.94 201.13,30.99 201.13,32.16 200.6,32.69 200.3,32.69 200.11,32.75 199.93,32.69 199.52,32.69 199.41,32.8 199.41,33.61 199.54,33.73 200.93,33.73
LAN_MCT0 on TOP (solid shape): 37.51,108.52 37.51,106.21 37.35,106.04 35.93,106.04 35.8,106.18 35.8,108.56 36.03,108.79 37.24,108.79
LAN_MCT0 on BOTTOM (solid shape): 37.01,110.29 37.01,107.56 36.89,107.45 36.56,107.45 36.4,107.61 36.4,110.3 36.41,110.31 36.99,110.31
LAN_MCT1 on TOP (solid shape): 35.12,108.34 35.12,106.17 35.06,106.11 33.21,106.11 33.09,106.23 33.09,108.65 33.22,108.78 33.45,108.78 33.46,108.79 34.67,108.79
LAN_MCT1 on BOTTOM (solid shape): 34.01,110.29 34.01,107.56 33.89,107.45 33.56,107.45 33.4,107.61 33.4,110.3 33.41,110.31 33.99,110.31
LAN_MCT2 on TOP (solid shape): 31.11,108.64 31.11,106.24 31.02,106.15 29.53,106.15 29.45,106.23 29.45,108.27 29.97,108.79 30.95,108.79
LAN_MCT2 on BOTTOM (solid shape): 31.01,110.29 31.01,107.56 30.89,107.45 30.56,107.45 30.4,107.61 30.4,110.3 30.41,110.31 30.99,110.31
LAN_MCT3 on TOP (solid shape): 28.7,108.62 28.7,106.28 28.39,105.97 26.91,105.97 26.8,106.08 26.8,108.47 27.12,108.79 28.52,108.79
LAN_MCT3 on BOTTOM (solid shape): 28.01,110.29 28.01,107.56 27.89,107.45 27.56,107.45 27.4,107.61 27.4,110.3 27.41,110.31 27.99,110.31
LANVCC on TOP (solid shape): 37.45,32.54 37.45,31.17 37.32,31.04 36.83,31.04 36.75,31.12 36.75,31.97 36.75,31.97 36.75,32.78 36.82,32.85 37.15,32.85
LANVCC on TOP (solid shape): 36.97,43.77 36.97,42.3 36.92,42.25 33.06,42.25 33.01,42.19 32.5,42.19 32.48,42.2 32.46,42.22 32.43,42.25 32.4,42.29 32.3,42.37 32.19,42.42 32.16,42.44 32.15,42.47 32.15,42.71 32.51,43.07 34.25,43.07 35.13,43.95 36.79,43.95
LANVCC on TOP (solid shape): 23.69,40.74 23.69,40.56 24.29,39.97 24.29,39.95 24.39,39.75 24.59,39.65 24.61,39.65 24.97,39.29 25.92,39.29 26.08,39.14 26.08,38.11 26,38.03 25.33,38.03 24.99,38.37 24.97,38.37 24.81,38.53 24.46,38.53 23.88,39.11 23.4,39.11 22.42,40.09 22.42,40.71 22.52,40.81 23.62,40.81
LANVCC on TOP (solid shape): outline of 135 points within 30.79,35.06 37.52,38.05
LANVCC on IN1 (solid shape): outline of 1053 points within 21.4,32.09 38.16,43.95
LANVCC on IN3 (solid shape): 36.52,36.44 36.52,32.48 37.11,31.9 37.11,31.11 36.94,30.94 35.94,30.94 35.69,31.2 35.69,34.61 34.81,35.48 34.81,36.12 34.82,36.16 34.86,36.18 35.2,36.56 34.86,36.94 34.82,36.95 34.81,36.99 34.81,37.11 35.09,37.39 35.57,37.39
LCDVCC on BOTTOM (solid shape): 66.18,128.93 66.18,127.02 66.16,126.99 66.13,126.97 65.39,126.97 65.36,126.98 65.34,127 65.18,127.19 64.97,127.3 64.95,127.31 64.89,127.37 64.89,129.34 64.91,129.38 64.94,129.39 65.72,129.39
LCDVCC on BOTTOM (solid shape): 63.54,109.87 63.62,109.86 63.73,109.86 64.01,109.59 64.01,109.59 64.05,109.57 64.07,109.54 64.06,109.52 64.03,109.24 64.13,108.97 64.13,108 64.12,107.88 64.12,106.91 63.25,106.04 62.07,106.04 62.07,106.04 62.07,106.78 62.3,107.02 62.3,107.25 62.3,107.95 62.14,108.11 61.74,108.11 61.54,108.31 61.54,109.16 61.69,109.32 61.71,109.33 61.73,109.34 62.19,109.34 62.37,109.16 62.38,109.14 62.39,109.12 62.39,109.04 62.48,109.04 62.52,109.01 63.11,109.01 63.23,109.12 63.23,109.73 63.38,109.89 63.45,109.89
LCDVCC on IN2 (solid shape): outline of 1668 points within 61.23,106.43 69.65,129.16
LCDVCC_R on BOTTOM (solid shape): 64.39,129.65 64.39,127.42 64.3,127.33 63.12,127.33 62.92,127.3 62.74,127.2 62.73,127.19 62.61,127.19 62.18,126.76 61.95,126.76 61.92,126.76 61.73,126.91 61.51,126.96 61.39,126.96 61.36,126.98 61.34,127.01 61.34,127.18 61.34,127.19 61.34,127.98 61.83,128.47 62.64,128.47 62.65,128.49 63,128.49 63.28,128.77 63.28,129.57 63.57,129.86 64.18,129.86
PHASE_A on BOTTOM (solid shape): 98.08,134.64 98.08,125.58 97.42,124.92 95.24,124.92 94.98,125.18 94.98,126.45 94.86,126.57 94.35,126.57 94.22,126.45 94.22,125.18 93.97,124.92 91.96,124.92 91.55,125.33 91.55,127.36 92.01,127.82 92.65,127.82 93.18,128.35 93.18,129.75 92.82,130.1 92.01,130.1 91.94,130.14 91.92,130.16 91.91,130.19 91.91,133.48 91.99,133.59 92.01,133.6 92.03,133.61 92.32,133.61 92.72,134.02 92.72,135.11 92.85,135.23 93.64,135.23 93.71,135.16 93.71,134.27 94.04,133.94 95.54,133.94 96.05,134.45 96.05,134.7 96.23,134.88 96.61,134.88 96.81,135.08 96.81,135.23 96.83,135.26 97.33,135.26 97.33,135.26 97.46,135.26
PHASE_C on TOP (solid shape): 76.23,129.17 76.23,127.17 75.99,126.94 75.11,126.94 74.99,127.06 74.99,127.85 74.6,128.24 74.6,129.2 74.74,129.34 76.06,129.34
PHASE_C on BOTTOM (solid shape): 80.91,135.34 80.91,127.28 80.33,126.7 77.96,126.7 77.58,127.08 77.58,127.84 77.46,127.97 77.08,127.97 76.95,127.84 76.95,126.83 76.82,126.7 74.33,126.7 74,127.03 74,128.84 74.01,128.86 74.02,128.88 74.27,129.11 75.12,129.11 75.27,129.27 75.27,130.36 75.47,130.56 77.48,130.56 78.07,131.15 78.07,132.95 78.19,133.08 79.46,133.08 79.64,133.25 79.64,134.63 79.92,134.9 79.92,135.41 79.95,135.45 79.97,135.46 79.99,135.46 80.44,135.46 80.44,135.46 80.78,135.46
R_SPK+ on BOTTOM (solid shape): 194.42,20.34 194.42,17.63 194.25,17.45 193.43,17.45 193.38,17.51 193.38,19.99 191.58,21.79 191.58,22.16 191.71,22.29 192.47,22.29
R_SPK+ on IN1 (solid shape): 193.15,22.72 193.15,21.42 192.72,20.99 192.16,20.99 191.88,21.27 191.88,22.52 191.68,22.71 191.68,22.92 192.11,23.35 192.52,23.35
R_SPK+ on IN1 (solid shape): 198.72,32.14 198.72,32.12 199.07,31.83 199.42,32.12 199.44,32.15 199.47,32.16 199.82,32.16 199.84,32.16 199.85,32.15 199.89,32.11 199.93,32.08 199.95,32.06 199.96,32.04 199.96,30.95 199.95,30.93 199.94,30.91 199.67,30.63 199.56,30.25 199.55,30.23 199.53,30.21 198,30.21 197.93,30.28 197.93,31.76 198.33,32.16 198.69,32.16
R_SPK- on BOTTOM (solid shape): 191.34,22 191.34,22 191.39,21.94 191.39,21.72 192.9,20.21 192.9,17.61 192.82,17.53 192.21,17.53 192.16,17.58 192.16,19.49 190.14,21.51 190.14,22.05 190.33,22.24 191.1,22.24
R_SPK- on IN1 (solid shape): 191.5,22.12 191.5,21.11 191.53,21.07 191.53,19.98 191.36,19.81 190.37,19.81 190.06,20.12 190.06,22.05 190.25,22.24 191.38,22.24
R_SPK- on IN1 (solid shape): 200.98,32.14 200.98,30.74 200.95,30.71 200.95,30 200.85,29.9 200.21,29.9 200.14,29.98 200.14,31.99 200.15,32.02 200.18,32.04 200.32,32.1 200.42,32.21 200.44,32.23 200.47,32.24 200.87,32.24
REGOUT on TOP (solid shape): 34.2,40.43 34.2,40.1 34.25,40.05 35.32,40.05 35.47,39.9 35.47,39.07 35.3,38.91 34.45,38.91 33.55,38.01 32.13,38.01 31.74,37.62 30.75,37.62 30.64,37.72 30.64,39.29 31.33,39.98 31.79,39.98 31.8,39.98 31.91,39.96 32.03,39.98 32.04,39.98 32.19,39.98 32.9,40.69 33.94,40.69
RING2 on TOP (solid shape): 212.81,22.15 212.81,21.34 212.71,21.24 211.69,21.24 211.59,21.14 211.03,20.58 210.91,20.46 210.91,18.95 210.89,18.92 210.86,18.9 209.94,18.9 209.74,19.11 209.74,20.91 210.29,21.46 210.86,21.46 211.15,21.75 210.87,22.04 211.06,22.23 212.74,22.23
RING2 on BOTTOM (solid shape): 211.01,19.39 211.01,18.8 211,18.8 211,17.5 211.01,17.5 211.01,17.3 210.96,17.25 209.78,17.25 209.7,17.33 209.7,17.5 210.7,17.5 210.7,18.8 210.5,18.8 210.5,17.5 210.2,17.5 210.2,18.8 210,18.8 210,17.5 209.7,17.5 209.7,17.57 209.7,17.57 209.7,18.8 209.69,18.8 209.69,19.1 209.7,19.13 209.71,19.19 209.71,19.24 209.7,19.3 209.69,19.36 209.84,19.51 210.88,19.51
RING2 on BOTTOM (solid shape): 201.54,22.74 201.54,22.58 201.51,22.43 201.53,22.31 201.54,22.3 201.54,21.94 201.53,21.92 201.52,21.72 201.61,21.55 201.61,21.15 201.6,21.12 201.56,21.08 201.54,21.05 201.5,20.97 201.48,20.88 201.48,20.86 201.44,20.81 201.16,20.81 201.05,20.78 200.95,20.78 200.92,20.79 200.9,20.81 200.51,21.13 200,21.1 199.99,21.1 199.87,21.1 199.85,21.12 199.85,21.69 200.96,22.8 200.96,22.81 200.98,22.85 201.01,22.87 201.41,22.87
RING2 on IN1 (solid shape): outline of 313 points within 199.2,18.09 210.83,23.3
SLEEVE on TOP (solid shape): 212.89,20.76 212.89,19.94 212.48,19.54 212.48,19.32 212.47,19.22 212.48,19.12 212.48,19 212.38,18.9 211.42,18.9 211.29,19.03 211.29,20.19 211.38,20.28 211.76,20.28 211.91,20.43 211.67,20.68 211.85,20.86 212.79,20.86
SLEEVE on BOTTOM (solid shape): 212.51,19.35 212.5,19.28 212.49,19.22 212.5,19.16 212.51,19.13 212.51,18.8 212.5,18.8 212.5,17.5 212.51,17.5 212.5,17.27 212.49,17.26 212.46,17.25 211.26,17.25 211.17,17.34 211.17,17.48 211.2,17.5 212.2,17.5 212.2,18.8 212,18.8 212,17.5 211.7,17.5 211.7,18.8 211.5,18.8 211.5,17.5 211.2,17.5 211.2,18.8 211.17,18.82 211.17,19.39 211.3,19.51 212.34,19.51
SLEEVE on BOTTOM (solid shape): 202.59,22.39 202.6,22.39 202.81,22.18 202.81,22.08 203.05,21.66 203.48,21.86 203.56,21.92 203.65,21.89 203.9,21.65 203.9,21.22 203.85,21.14 203.76,21.12 203.3,21.13 202.93,20.86 202.92,20.84 202.89,20.83 202.25,20.83 202.21,20.85 202.2,20.88 202.11,21.09 201.93,21.2 201.91,21.21 201.89,21.23 201.89,21.49 201.71,21.67 201.71,21.69 201.64,21.76 201.64,22.6 201.74,22.71 202.27,22.71
SLEEVE on IN1 (solid shape): outline of 206 points within 201.59,18.62 212.76,23.93
SY8286BBST on BOTTOM (solid shape): 126.98,131.5 127.04,131.45 127.04,131.17 126.92,131.05 126.47,131.05 125.72,130.3 125.72,130.02 124.17,128.48 122.63,128.48 122.38,128.73 122.63,128.99 123.96,128.99 125.21,130.23 125.21,130.51 126.2,131.51
SY8286BSW on BOTTOM (solid shape): 127.43,131.27 127.47,131.26 127.48,131.22 127.48,130.58 127.68,130.58 127.68,131.22 127.69,131.26 127.73,131.27 127.88,131.27 127.92,131.26 127.93,131.22 127.93,130.58 127.95,130.56 127.95,130.38 127.9,130.33 127.9,129.7 128.05,129.55 129.09,129.55 129.88,128.76 129.9,128.74 129.9,128.7 129.88,128.67 129.74,128.4 129.85,128.1 130.03,127.91 130.03,127.34 129.81,127.11 122.73,127.11 122.57,127.26 122.57,127.79 122.73,127.94 123.99,127.94 125.12,129.08 125.4,129.08 127.21,130.89 127.21,131.15 127.34,131.27
SY8288CBST on BOTTOM (solid shape): 140.34,81.09 141.11,81.09 141.15,81.05 141.15,80.82 141.02,80.69 141.01,80.69 140.82,80.5 140.36,80.5 140.06,80.2 140.06,79.55 139.94,79.43 139.23,79.43 139.18,79.48 139.18,80.83 139.48,81.13 140.3,81.13
SY8288CSW on BOTTOM (solid shape): 141.57,83.67 141.57,82.99 141.55,82.95 141.51,82.94 141.41,82.94 140.58,83.77 140.58,84.08 140.68,84.18 141.06,84.18
