# Allegro board Quanta Z8P DA0Z8PMB8D0 REV D - BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
INT_HDMITX0P: length 160.6
  TOP w0.127: C125.1 36.51,60.58 36.25,60.58 v1(36.06,60.39) 35.88,60.57 35.37,60.57 35.27,60.47 C124.1
  IN1 w0.102: v1(107.06,85.94) 107.44,85.55 109.94,85.55 110.3,85.91 113.86,85.91 115.07,84.69 115.07,84.24 119.82,79.5 119.82,67.3 121.88,65.23 121.88,51.49 118.45,48.06 118.45,45.26 116.06,42.88 116.06,42.03 112.03,38 50.42,38 46.01,42.41 44.96,42.41 39.68,47.7 39.68,54.96 35.6,59.04 35.6,60.46 35.71,60.57 35.89,60.57 v1(36.06,60.39)
  BOTTOM w0.102: U21.AH3 104.19,85.41 104.34,85.26 104.35,85.26 104.49,85.12 104.74,85.12 104.88,85.26 104.89,85.26 104.96,85.33 105.29,85.33 106.34,86.38 107.25,86.38 107.34,86.29 107.34,86.22 v1(107.06,85.94)
INT_HDMITX0P_C: length 15.3
  TOP w0.127: CN6.7 11.15,65.85 11.55,66.25 11.69,66.25 11.8,66.14 11.8,62.18 12.43,61.55 13.03,61.55 v1(13.3,61.28) ; R142.1 18.73,61.5 18.63,61.61 18.25,61.61 v1(17.92,61.28)
  BOTTOM w0.127: v1(13.3,61.28) 13.57,61.55 14.06,61.55 14.33,61.82 14.33,62.18 14.46,62.31 14.59,62.31 14.7,62.2 ESD7.1 ESD7.10 16.34,62.2 16.46,62.32 16.64,62.32 16.77,62.2 16.77,61.78 17,61.55 17.66,61.55 v1(17.92,61.28) 17.92,61.47 18.05,61.6 18.6,61.6 18.73,61.48 R410.1
INT_HDMITX0P_C_RIN: length 5
  TOP w0.127: C124.2 34.49,60.48 34.4,60.56 34,60.56 33.63,60.94 33.63,62.93 32.97,63.59 32.8,63.59 32.68,63.48 U6.25
INT_HDMITX0P_C_ROUT: length 9.7
  TOP w0.127: U6.16 26.7,63.48 26.62,63.56 26.49,63.56 26.33,63.4 26.33,62.36 25.98,62.02 25.71,62.02 v1(25.12,61.42) 24.52,62.02 23.55,62.02 23.12,61.59 19.85,61.59 R142.2
INT_HDMITX0P_NOR: length 22.6
  TOP w0.127: v1(38.43,60.39) 38.2,60.63 38.04,60.63 C125.2 ; R143.1 v1(20.3,61.13)
  BOTTOM w0.127: v1(38.43,60.39) 38.31,60.51 37.92,60.51 36.41,59.01 34.73,59.01 33.59,60.15 25.21,60.15 23.74,61.62 20.79,61.62 v1(20.3,61.13) 20.18,61.25 R410.2
INT_HDMITX1N: length 162.7
  TOP w0.127: C116.1 35.27,64.05 35.43,63.89 35.85,63.89 v1(36.06,64.1) 36.27,63.9 36.5,63.9 C117.1
  IN1 w0.102: v1(36.06,64.1) 35.87,63.9 35.5,63.9 35.22,63.62 35.22,62.55 35.66,62.11 39.07,62.11 40.17,61.01 40.17,47.9 45.17,42.91 46.21,42.91 50.64,38.48 111.81,38.48 115.57,42.24 115.57,43.08 117.92,45.43 117.92,48.21 121.4,51.69 121.4,65.01 119.33,67.08 119.33,79.27 113.25,85.35 110.8,85.35 110.49,85.04 107.17,85.04 105.79,83.66 105.79,83.31 v1(105.56,83.08)
  BOTTOM w0.102: U21.AM2 104.76,83.56 104.89,83.43 105.22,83.43 v1(105.56,83.08)
INT_HDMITX1N_C: length 9
  TOP w0.127: v1(14.06,64.36) 14.06,64.34 13.93,64.22 13.7,64.22 13.58,64.34 13.58,64.62 13.3,64.89 12.83,64.89 12.7,65.02 CN6.6 ; v1(17.92,64.35) 18.25,64.03 18.63,64.03 18.73,64.13 R135.1
  BOTTOM w0.127: v1(14.06,64.36) 14.34,64.08 14.46,64.08 14.59,64.2 ESD7.5 ESD7.6 16.34,64.2 16.46,64.08 17.08,64.08 17.13,64.03 17.6,64.03 v1(17.92,64.35) 17.92,64.15 18.05,64.02 18.57,64.02 18.73,64.18 R135.1
INT_HDMITX1N_C_RIN: length 2.9
  TOP w0.127: C116.2 34.49,64.05 34.36,63.92 34.01,63.92 33.06,64.87 32.76,64.87 32.65,64.98 U6.28
INT_HDMITX1N_C_ROUT: length 8.5
  TOP w0.127: U6.13 26.7,64.98 26.53,64.81 26.23,64.81 25.65,64.22 24.28,64.22 v1(23.91,64.59) 23.34,64.01 19.87,64.01 R135.2
INT_HDMITX1N_NOR: length 22.6
  TOP w0.127: v1(38.43,64.12) 38.26,63.95 37.95,63.95 C117.2 ; R134.1 v1(20.3,64.5)
  BOTTOM w0.127: R407.2 20.18,64.38 v1(20.3,64.5) 20.81,63.99 24.85,63.99 26.66,62.18 28.05,62.18 28.56,62.69 34.86,62.69 35.17,62.39 36.49,62.39 37.96,63.86 38.17,63.86 v1(38.43,64.12)
INT_HDMITX1P: length 162.7
  TOP w0.127: C118.1 35.27,63.53 35.37,63.63 35.88,63.63 v1(36.06,63.45) 36.25,63.64 36.51,63.64 C119.1
  IN1 w0.102: v1(106.23,83.08) 106,83.31 106,83.58 107.26,84.84 110.58,84.84 110.88,85.15 113.16,85.15 119.13,79.18 119.13,66.99 121.2,64.93 121.2,51.78 117.72,48.3 117.72,45.51 115.37,43.17 115.37,42.32 111.72,38.68 50.72,38.68 46.3,43.11 45.25,43.11 40.37,47.99 40.37,61.09 39.15,62.32 35.74,62.32 35.42,62.64 35.42,63.53 35.59,63.7 35.82,63.7 v1(36.06,63.45)
  BOTTOM w0.102: U21.AM3 104.2,83.56 104.53,83.88 104.71,83.88 104.96,83.63 105.29,83.63 105.42,83.5 105.81,83.5 v1(106.23,83.08)
INT_HDMITX1P_C: length 9
  TOP w0.127: CN6.4 13.03,64.64 13.19,64.64 13.32,64.51 13.32,64.22 13.59,63.95 13.83,63.95 14.06,63.72 v1(14.06,63.54) ; R137.1 18.73,63.67 18.63,63.77 18.25,63.77 v1(17.92,63.45)
  BOTTOM w0.127: v1(14.06,63.54) 14.34,63.82 14.46,63.82 14.59,63.7 ESD7.4 ESD7.7 16.34,63.7 16.46,63.82 16.98,63.82 17.03,63.77 17.6,63.77 v1(17.92,63.45) 17.92,63.64 18.05,63.77 18.6,63.77 18.73,63.64 R408.1
INT_HDMITX1P_C_RIN: length 2.9
  TOP w0.127: C118.2 34.49,63.47 34.3,63.66 33.91,63.66 32.96,64.61 32.78,64.61 32.65,64.48 U6.27
INT_HDMITX1P_C_ROUT: length 8.5
  TOP w0.127: U6.14 26.7,64.48 26.63,64.55 26.33,64.55 25.75,63.97 24.56,63.97 v1(23.91,63.32) 23.47,63.76 19.85,63.76 R137.2
INT_HDMITX1P_NOR: length 22.6
  TOP w0.127: R138.1 v1(20.3,63.3) ; C119.2 38.04,63.69 38.2,63.69 v1(38.43,63.46)
  BOTTOM w0.127: R408.2 20.18,63.42 v1(20.3,63.3) 20.74,63.73 24.75,63.73 26.55,61.93 28.16,61.93 28.67,62.44 34.75,62.44 35.06,62.13 36.59,62.13 38.06,63.61 38.28,63.61 v1(38.43,63.46)
INT_HDMITX2N: length 161.5
  TOP w0.127: C112.1 35.27,67.11 35.43,66.95 35.85,66.95 v1(36.06,67.16) 36.27,66.96 36.5,66.96 C113.1
  IN1 w0.102: v1(108.23,83.16) 108.39,83.16 108.87,83.63 110.04,83.63 110.15,83.52 112.84,83.52 117.96,78.4 117.96,66.47 120.02,64.41 120.02,52.26 116.52,48.76 116.52,46.01 114.17,43.66 114.17,42.82 111.2,39.85 51.25,39.85 46.79,44.3 45.75,44.3 41.57,48.48 41.57,65.37 38.73,68.21 35.92,68.21 35.54,67.83 35.54,67.04 35.67,66.91 35.95,66.91 36.06,67.02 v1(36.06,67.16)
  BOTTOM w0.089: U21.AK2 105.99,84.48 106.01,84.47 106.03,84.47
  BOTTOM w0.102: 106.03,84.47 107.8,84.47 108.53,83.74 108.59,83.68 108.59,83.27 108.47,83.16 v1(108.23,83.16)
INT_HDMITX2N_C: length 14.3
  TOP w0.127: v1(17.92,66.52) 18.25,66.19 18.59,66.19 18.73,66.33 R130.1
  IN1 w0.102: CN6.3 11.51,63.45 11.8,63.45 12.05,63.2 12.05,62.95 12.31,62.69 13.03,62.69 13.32,62.98 13.32,66.5 13.58,66.76 13.78,66.76 v1(14.06,67.04)
  BOTTOM w0.127: v1(14.06,67.04) 14.24,66.86 14.46,66.86 14.62,67.02 ESD6.2 ESD6.9 16.34,67.02 16.46,66.9 16.75,66.9 17.4,66.25 17.77,66.25 17.92,66.41 v1(17.92,66.52) 18.25,66.19 18.57,66.19 18.73,66.35 R130.1
INT_HDMITX2N_C_RIN: length 3
  TOP w0.127: U6.30 32.65,65.98 32.76,65.87 32.91,65.87 34.01,66.98 34.4,66.98 34.49,67.07 C112.2
INT_HDMITX2N_C_ROUT: length 8.4
  TOP w0.127: U6.11 26.69,65.98 26.54,65.84 26.22,65.84 v1(25.7,66.36) 25.2,65.87 22.59,65.87 22.28,66.18 19.87,66.18 R130.2
INT_HDMITX2N_NOR: length 23.5
  TOP w0.127: C113.2 37.95,67.01 38.26,67.01 v1(38.43,67.18) ; R129.1 v1(20.3,66.67)
  BOTTOM w0.127: v1(38.43,67.18) 38.18,66.93 37.98,66.93 36.5,65.45 34.77,65.45 32.07,68.15 27.06,68.15 25.05,66.15 20.82,66.15 v1(20.3,66.67) 20.18,66.55 R405.2
INT_HDMITX2P: length 161.5
  TOP w0.127: C115.1 36.51,66.71 36.25,66.71 v1(36.06,66.52) 35.88,66.7 35.37,66.7 35.27,66.6 C114.1
  IN1 w0.102: v1(108.98,83.16) 109.25,83.43 109.95,83.43 110.06,83.32 112.75,83.32 117.76,78.31 117.76,66.39 119.82,64.33 119.82,52.34 116.32,48.84 116.32,46.09 113.97,43.74 113.97,42.9 111.12,40.05 51.33,40.05 46.88,44.51 45.83,44.51 41.77,48.57 41.77,65.46 38.82,68.41 35.84,68.41 35.34,67.91 35.34,66.96 35.59,66.71 35.87,66.71 v1(36.06,66.52)
  BOTTOM w0.089: U21.AK3 104.43,84.7 104.5,84.77 104.7,84.77 104.86,84.66 105.99,84.66 106.01,84.67 106.03,84.67
  BOTTOM w0.102: 106.03,84.67 107.89,84.67 108.79,83.77 108.79,83.34 v1(108.98,83.16)
INT_HDMITX2P_C: length 14.4
  TOP w0.127: R132.1 18.73,65.83 18.63,65.94 18.25,65.94 v1(17.92,65.62)
  IN1 w0.102: CN6.1 11.59,63.25 11.71,63.25 11.85,63.12 11.85,62.86 12.22,62.49 13.12,62.49 13.52,62.9 13.52,66.42 13.66,66.55 13.88,66.55 v1(14.06,66.38)
  BOTTOM w0.127: v1(14.06,66.38) 14.29,66.61 14.46,66.61 14.55,66.52 ESD6.1 ESD6.10 16.34,66.52 16.46,66.64 16.64,66.64 17.29,65.99 17.54,65.99 v1(17.92,65.62) 17.92,65.81 18.05,65.94 18.6,65.94 18.73,65.81 R406.1
INT_HDMITX2P_C_RIN: length 3
  TOP w0.127: U6.29 32.63,65.48 32.76,65.62 33.01,65.62 34.12,66.72 34.33,66.72 34.49,66.57 C114.2
INT_HDMITX2P_C_ROUT: length 8.4
  TOP w0.127: R132.2 19.85,65.93 22.17,65.93 22.49,65.61 25.18,65.61 v1(25.7,65.09) 26.18,65.58 26.59,65.58 26.69,65.48 U6.12
INT_HDMITX2P_NOR: length 23.5
  TOP w0.127: C115.2 38.04,66.76 38.2,66.76 v1(38.43,66.52) ; R133.1 v1(20.3,65.46)
  BOTTOM w0.127: v1(38.43,66.52) 38.27,66.68 38.09,66.68 36.6,65.19 34.67,65.19 31.96,67.9 27.16,67.9 25.16,65.89 20.73,65.89 v1(20.3,65.46) 20.18,65.59 R406.2
INTRUDER#: length 2.9
  TOP w0.14: R62.1 82.27,88.08 82.13,88.23 81.4,88.23 v1(81.34,88.17) 80.88,88.17 v1(80.48,87.76)
  BOTTOM w0.102: U21.AC54 80.1,87.32 80.48,87.7 v1(80.48,87.76)
IRQ_SERIRQ: length 167.9
  TOP w0.14: v1(129.49,33.51) 129.42,33.59 127.98,33.59 127.74,33.35 v1(127.74,29.49) 128.67,28.57 130.28,28.57 130.57,28.86 U16.5 ; v1(132.69,41.25) 132.12,41.81 131.05,41.81 129.33,43.53 120.17,43.53 116.16,39.52 114.76,39.52 113.26,38.02 103.11,38.02 101.86,36.77 53.12,36.77 48.38,41.5 48.38,45.6 43.51,50.48 43.51,53.14 45.63,55.27 45.63,62.47 53.99,70.83 57.68,70.83 58.29,71.43 58.29,76.28 59.51,77.5 v1(59.51,80.05)
  IN1 w0.114: v1(129.49,33.51) 128.5,33.51 127.74,34.27 127.74,34.47 127.26,34.95 127.26,35.43 128.56,36.73 128.56,37.47 129.35,38.27 130.02,38.27 131.81,40.06 131.81,40.37 v1(132.69,41.25)
  BOTTOM w0.127: v1(59.51,80.05) 59.51,81.81 58.11,83.21 58.11,84.64 58.72,85.25 U22.3
ISL95857_COMP_A: length 2.4
  TOP w0.254: PC18.2 v1(110.61,123.4)
  BOTTOM w0.191: PC18.2 v1(110.61,123.4) 111.02,123.4 111.09,123.47 PU6.16
ISL95857_COMP_C: length 3.7
  TOP w0.254: v1(113.02,127.41) 113.02,127.74 112.84,127.92 PC10.2
  BOTTOM w0.203: PC10.2 112.84,127.95 113.02,127.77 v1(113.02,127.41) 113.02,127.4 113.56,126.86 PU6.24
ISL95857_FB_A: length 5.4
  TOP w0.254: PR26.1 108.59,123.92 109.67,123.92 109.98,124.23 PR23.1 110.29,124.54 v1(110.59,124.24)
  BOTTOM w0.203: PU6.17 110.96,123.87 v1(110.59,124.24) 110.29,124.54 PR23.1
ISL95857_FB_C: length 5
  TOP w0.254: v1(114.96,127.58) 115.04,127.66 PR13.1
  BOTTOM w0.203: PR107.1 PR106.1 113.96,127.44 v1(113.85,127.34) 113.96,127.23 PU6.25
  BOTTOM w0.254: PR107.1 115.04,127.66 v1(114.96,127.58)
ISL95857_FCCM_A: length 3.2
  BOTTOM w0.203: PR103.2 110.81,127.49 v1(110.91,127.39) 112.36,125.93 PU6.21
ISL95857_FCCM_C: length 3.8
  BOTTOM w0.203: PU6.29 115.56,126.02 115.74,126.2 116.73,126.2 117.18,126.66 117.8,126.66 PR108.2
ISL95857_IMON_A: length 3.2
  BOTTOM w0.203: PU6.14 111.41,122.67 110.84,122.1 v1(110.78,122.1) 110.58,122.1 110.43,122.26 PC100.1
  BOTTOM w0.254: PR128.1 PC100.1
ISL95857_IMON_C: length 5.3
  TOP w0.127: PR11.1 110.61,128.22 110.2,128.63 v1(109.84,128.63)
  TOP w0.254: v1(112.32,127.72) PC9.1 PR11.1
  BOTTOM w0.203: PU6.23 113.16,126.53 112.32,127.37 v1(112.32,127.72)
ISL95857_ISUMN_A: length 3.5
  BOTTOM w0.203: PR111.1 PC91.2 v1(110.93,125.94) 110.93,125.59 111.45,125.07 PU6.20
ISL95857_ISUMN_C: length 4.6
  TOP w0.254: PR14.1 v1(117.46,127.58)
  BOTTOM w0.203: PU6.28 115.16,126.1 115.59,126.53 116.33,126.53 v1(116.95,127.16) 117.04,127.16 v1(117.46,127.58) PR14.1
ISL95857_NTC_A: length 17.2
  TOP w0.254: PR32.1 110.29,122.26 v1(110.79,122.76) 111.15,123.12 111.15,125.28 108.83,127.6 106.77,127.6 106.26,127.08 103.3,127.08 v1(103.17,126.95)
  BOTTOM w0.203: v1(110.79,122.76) 111.1,123.07 PU6.15
  BOTTOM w0.254: PR113.1 v1(103.17,126.95)
ISL95857_PROG1: length 2.1
  TOP w0.254: PR20.1 v1(117.66,125.18)
  BOTTOM w0.203: v1(117.66,125.18) 117.41,125.18 116.91,124.67 PU6.32
ISL95857_PROG2: length 2.4
  TOP w0.254: PR18.1 117.99,126.32 v1(117.49,125.81)
  BOTTOM w0.203: PU6.31 116.75,125.07 v1(117.49,125.81)
ISL95857_PSYS: length 1.6
  BOTTOM w0.203: TP30.1 115.96,120.09 PU6.1
ISL95857_PWM_A: length 2.9
  BOTTOM w0.203: PU6.22 112.76,126.22 v1(112.2,126.78) 111.82,127.16 PR104.2
ISL95857_PWM_C: length 2.8
  BOTTOM w0.203: PR112.2 117.31,126.32 116.66,125.67 PU6.30
ISL95857_RTN_A: length 12
  TOP w0.254: v1(105.45,123.03) 105.27,123.03 PC17.2 104.77,124.16 PR21.1 104.39,124.55 v1(105.26,125.42)
  BOTTOM w0.203: PU6.18 111.26,124.27 110.49,125.04 105.65,125.04 v1(105.26,125.42)
  BOTTOM w0.254: PC98.2 106.11,123.41 105.73,123.03 v1(105.45,123.03) 105.27,123.03 PC17.2
ISL95857_RTN_C: length 13
  TOP w0.254: v1(115.56,131.55) 115.56,130.4 115.42,130.26 PC5.2 114.89,130.26 114.11,131.04 PC4.2
  BOTTOM w0.191: PU6.26 114.36,126.16
  BOTTOM w0.203: v1(115.56,131.55) 115.54,131.54 115.54,128.1 115.61,128.03 v1(115.61,127.36) 115.58,127.34 115.42,127.34 114.36,126.27 114.36,126.16
  BOTTOM w0.254: PR97.2 PR96.1 117.22,132.28 117.22,131.93 116.88,131.58 115.58,131.58 v1(115.56,131.55)
ISL95857_SCLK: length 2.1
  BOTTOM w0.203: PR123.1 118.24,122.48 v1(117.61,122.48) 117.42,122.67 PU6.37
ISL95857_SDA: length 2.3
  TOP w0.254: PR24.2 117.62,124.03 117.42,123.83 v1(117.42,123.51)
  BOTTOM w0.191: v1(117.42,123.51) 117.38,123.47 PU6.35
ISL95857_VCC: length 4.8
  BOTTOM w0.203: PU6.34 116.91,123.87 116.96,123.93 117.13,123.93 117.34,124.13 v1(117.64,124.13) 117.74,124.03 PC95.1
  BOTTOM w0.254: PC95.1 118.47,124.36 118.67,124.56 PR117.2
ISL95857_VIN: length 5.2
  BOTTOM w0.203: PU6.33 116.99,124.27 117.4,124.68 117.97,124.68 PC92.1
  BOTTOM w0.254: PR114.1 120.44,125.71 118.66,125.71 118.47,125.51 PC92.1
ISL95857_VR_EN: length 2.1
  BOTTOM w0.203: PU6.40 116.72,121.47 116.94,121.25 PR133.1
ISL95857_VR_HOT: length 2.1
  BOTTOM w0.203: PR127.1 117.65,121.75 117.13,122.27 PU6.38
ISL95857_VR_READY: length 2.4
  BOTTOM w0.203: PR130.1 118.29,120.6 117.02,121.87 PU6.39
ISOLATEB: length 6.4
  TOP w0.14: R224.2 v1(36,33.55) R225.1 34.88,33.55 34.36,34.08 33.83,34.08 33.02,34.89 32.6,34.89 31.77,35.71 U13.31
ISUMN_A: length 26.2
  TOP w0.254: v1(108.56,126.46) 108.55,126.46 PC12.2 PR19.1
  IN1 w0.254: v1(108.56,126.46) 106.48,124.38 105.17,124.38 104.13,123.34 v1(102.56,123.34)
  BOTTOM w0.254: PR116.2 99.16,125.79 99.6,126.22 v1(100.77,126.22) 104.99,126.22 105.49,126.72 PC90.1 106.64,127.6 107.6,127.6 107.93,127.27 PC12.2 PR111.2 108.57,126.46 v1(108.56,126.46) 108.56,126.45 107.19,126.45 107.15,126.41 PR115.2 ; v1(102.56,123.34) 101.81,122.59 PR126.1
ISUMN_C: length 68.3
  TOP w0.254: v1(118.35,131.04) 117.56,131.04 ; 117.56,131.04 PC6.1 ; 117.56,131.04 118.3,130.31 v1(118.3,129.9) 118.3,129.55 117.75,129 PR14.2 PC11.1
  IN1 w0.254: v1(118.35,131.04) 118.48,131.15 118.48,131.75 114.2,136.03 103.62,136.03 100.02,139.64 88.09,139.64 84.96,136.51 84.96,129.6 83.85,128.49 v1(82.67,128.49)
  BOTTOM w0.254: PC11.1 116.11,129 115.9,129.21 115.9,130.8 116.14,131.04 PR100.1 PC6.1 v1(118.35,131.04) 119.35,131.04 119.7,131.4 119.7,132.68 119.34,133.05 116.02,133.05 115.38,133.69 114.63,133.69 PR94.1 ; PR110.2 v1(82.67,128.49)
ISUMP_A: length 18
  TOP w0.254: PR22.2 105.51,124.94 v1(106.52,125.94) PR19.2 PC12.1
  IN1 w0.254: v1(106.52,125.94) 106.52,125.72 105.73,124.93 103.2,124.93 v1(102.56,124.29)
  BOTTOM w0.203: PC90.2 106.32,125.38 110.63,125.38 111.34,124.67 PU6.19
  BOTTOM w0.254: v1(102.56,124.29) 102.3,124.03 PR121.1 ; v1(106.52,125.94) PC90.2
ISUMP_C: length 15.3
  TOP w0.254: PC11.2 v1(116.42,127.58) ; PR6.2 v1(116.42,129.63)
  IN1 w0.254: v1(116.42,129.63) 115.54,129.63 115.05,130.11 115.05,133.09 114.52,133.63 v1(114.52,134.31)
  BOTTOM w0.203: PC11.2 v1(116.42,127.58) 116.42,127.13 116.15,126.87 115.45,126.87 114.76,126.17 PU6.27
  BOTTOM w0.254: v1(114.52,134.31) 114.39,134.18 PR91.1 ; v1(116.42,129.63) PR6.2 116.78,130.26 116.94,130.1 116.94,128.42 116.74,128.22 PC11.2
KB_BL_LED: length 109.6
  TOP w0.127: 232.17,13.14 231.93,13.37 Q23.2
  TOP w0.14: v1(232.45,12.86) 232.17,13.14 ; v1(139.08,30.79) U16.113
  IN2 w0.127: v1(178.68,18.5) 178.68,21.18 172.47,27.39 164.77,27.39 164.39,27.01 160.58,27.01 160.31,27.27 153.73,27.27 152.74,28.27 152.74,29.42 151.83,30.33 150.87,30.33 150.37,29.82 150.37,28.87 149.32,27.82 147.91,27.82 147.3,28.43 147.3,29.05 146.67,29.68 142.68,29.68 141.58,30.79 v1(139.08,30.79)
  IN3 w0.14: v1(232.45,12.86) 231.99,12.4 184.08,12.4 178.68,17.81 v1(178.68,18.5)
KBRST#: length 2.3
  TOP w0.14: TP20.1 130.19,29.05 130.41,29.26 U16.4
L_SPK+: length 26.2
  TOP w0.203: U15.42 202.09,30.43 201.91,30.62 201.91,31.26 v1(202.12,31.48)
  TOP w0.508: v1(202.12,32.14) v1(202.12,31.48)
  IN1 w1.016: 186.28,23.66 186.28,27.57 194.25,35.54 197.6,35.54 198.48,34.65 201.46,34.65 202.04,34.07
  vias: v1(187.12,21.81) v1(187.12,21.13)
L_SPK-: length 22.7
  TOP w0.203: U15.43 201.69,30.4 201.38,30.71 v1(201.38,31.22)
  TOP w0.508: v1(201.38,31.91) v1(201.38,31.22)
  IN1 w1.016: 200.57,33.25 197.91,33.25 197.02,34.14 194.83,34.14 187.68,26.99 187.68,24.24 188.42,23.5 188.42,23.12
  vias: v1(188.65,21.95) v1(188.65,21.29)
LAN_MCT0:
  vias: v1(36.05,108.11) v2(36.69,108.5) v2(36.69,107.74)
LAN_MCT1:
  vias: v1(34.48,107.98) v2(33.69,108.5) v2(33.69,107.74)
LAN_MCT2:
  vias: v1(29.78,108.03) v2(30.69,108.5) v2(30.69,107.74)
LAN_MCT3:
  vias: v1(28.41,108.13) v2(27.69,108.5) v2(27.69,107.74)
LAN_MX0+: length 28.7
  TOP w0.127: v1(16.39,106.85) 16.4,106.84 16.4,106.2 16.01,105.81 14.41,105.81 CN4.1
  BOTTOM w0.127: v1(16.39,106.85) 16.39,105.96 18.06,104.29 33.19,104.29 35.7,106.8 35.7,108.87 35.7,108.87 U20.23
LAN_MX0-: length 28.8
  TOP w0.127: CN4.2 14.45,104.96 14.67,105.18 16.27,105.18 17.03,105.94 17.03,106.76 17.11,106.85 v1(17.76,106.85)
  BOTTOM w0.127: v1(17.76,106.85) 17.1,106.85 17.03,106.77 17.03,106.22 18.32,104.92 32.93,104.92 35.07,107.06 35.07,108.55 34.7,108.92 U20.22
LAN_MX1+: length 26.1
  IN1 w0.102: v1(32.81,105.81) 32.55,106.07 32.55,106.7 31.96,107.29 21,107.29 16.98,103.27 CN4.3
  BOTTOM w0.127: U20.20 32.7,108.91 32.48,108.68 32.48,106.14 v1(32.81,105.81)
LAN_MX1-: length 26.1
  IN1 w0.102: CN4.6 15.3,101.06 15.3,102.35 15.61,102.66 17.23,102.66 21.25,106.68 31.71,106.68 31.94,106.44 31.94,105.88 31.87,105.81 v1(31.54,105.81)
  BOTTOM w0.127: U20.19 31.7,108.93 31.85,108.79 31.85,105.92 31.74,105.81 v1(31.54,105.81)
LAN_MX2+: length 23.4
  TOP w0.127: CN4.4 14.83,101.87 15.79,101.87 19.54,105.61 19.54,108.01 v1(19.53,108.03)
  BOTTOM w0.127: U20.17 29.7,108.95 29.65,108.89 29.65,107.42 28.29,106.07 20.68,106.07 19.54,107.21 19.54,108.01 v1(19.53,108.03)
LAN_MX2-: length 23.4
  TOP w0.127: CN4.5 16.05,101.23 20.17,105.35 20.17,108.01 v1(20.19,108.03)
  BOTTOM w0.127: U20.16 28.7,108.92 29.01,108.61 29.01,107.69 28.03,106.7 20.94,106.7 20.17,107.47 20.17,108.01 v1(20.19,108.03)
LAN_MX3+: length 22.4
  TOP w0.127: CN4.7 14.33,99.36 16.11,99.36 18.82,102.07 v1(18.82,102.52) 21.75,105.45 v1(21.75,108.95)
  BOTTOM w0.127: U20.14 26.7,108.92 26.7,108.11 26.18,107.59 22.29,107.59 21.75,108.13 v1(21.75,108.95)
LAN_MX3-: length 22.5
  TOP w0.127: CN4.8 14.45,98.58 14.6,98.72 16.37,98.72 19.26,101.61 v1(19.73,101.61) 19.46,101.89 19.46,102.26 22.39,105.19 22.39,108.87 22.46,108.95 v1(22.97,108.95)
  BOTTOM w0.127: v1(22.97,108.95) 22.47,108.95 22.39,108.86 22.39,108.4 22.56,108.23 25.92,108.23 26.07,108.37 26.07,108.54 25.7,108.91 U20.13
LAN_XTAL2: length 6.1
  TOP w0.127: U13.45 27.18,39.13 27.35,39.3 27.35,39.68 27.85,40.17 27.85,40.5 27.73,40.62 C179.2 27.79,41.06 27.79,42.46 27.68,42.56 27.37,42.56 Y2.3
LAN_XTALI: length 6.1
  TOP w0.127: Y2.1 28.04,42.73 28.04,41.06 C180.2 28.24,40.62 28.07,40.46 28.07,40.08 27.58,39.58 U13.44
LANVCC: length 4
  TOP w0.102: v1(21.86,32.54) 22.1,32.29 v1(23.16,32.29)
  TOP w0.203: C215.2 23.92,33.26 24.08,33.26 24.53,33.71 U13.11
  TOP w0.508: C215.2 23.52,32.65 v1(23.16,32.29)
  vias: v1(22.74,40.6) v1(23.23,39.71) v1(33.49,36.89) v1(35.09,35.92) v1(35.23,37.06) v1(35.75,35.88) v1(35.9,37.05) v1(36.92,31.35) v2(36.66,43.36) v2(36.66,42.6)
LCDVCC:
  vias: v1(61.71,108.24) v1(62.22,108.69) v2(65.31,128.75) v2(65.6,127.02) v2(66.01,127.94)
LCDVCC_R: length 3.1
  BOTTOM w0.305: CN3.35 61.72,127.45 ; CN3.34 61.72,126.95 ; CN3.36 61.72,127.95
  vias: v1(62.77,127.67)
LID#: length 270.6
  TOP w0.127: D1.1 v1(44.49,109.94) ; v1(135.96,29.81) 136.92,28.85 136.92,26.32 137.48,25.76 v1(137.48,21.14)
  TOP w0.14: v1(134.39,38.59) 134.86,38.59 R204.2 ; Q14.1 3.52,57.01 10.18,57.01 13.18,60.01 20.96,60.01 21.32,60.37 v1(22.53,60.37)
  IN3 w0.127: v1(137.48,21.14) 137.48,21.06 136.99,20.58 133.84,20.58 132.2,22.23 130.48,22.23 127.76,24.94 123.47,24.94 123.21,24.68 122.89,24.68 119.62,21.41 119.62,16.11 118.91,15.4 84.84,15.4 81.84,12.4 41.83,12.4 31.98,22.25 29.15,22.25 23.61,27.79 23.61,32.94 24.53,33.86 24.53,38.09 23.39,39.22 23.39,40.96 23.18,41.17 23.18,56.36 23.1,56.44 23.1,59.8 v1(22.53,60.37) 23.1,60.94 23.1,70.42 24.88,72.2 24.88,74.85 24.48,75.25 24.48,78.34 25.63,79.49 25.63,89.55 30.25,94.16 33.14,94.16 36.09,97.11 42.34,97.11 44.52,99.3 44.52,106.42 45.07,106.97 45.07,109.35 v1(44.49,109.94)
  BOTTOM w0.14: v1(135.96,29.81) 135.99,29.84 135.99,36 134.19,37.8 134.19,38.39 v1(134.39,38.59)
LINE1-L: length 6.4
  TOP w0.203: U15.22 203.29,22.96 203.47,22.78 204.27,22.78 v1(204.7,23.22)
  BOTTOM w0.508: v1(204.7,23.22) 204.98,23.22 205.35,23.59 205.35,24.76 205.79,25.2 C423.1
LINE1-R: length 4.9
  TOP w0.203: U15.21 202.89,22.93 203.54,22.28 204.07,22.28
  TOP w0.508: 204.07,22.28 205.73,22.28 v1(206.04,21.97)
  BOTTOM w0.508: C444.1 206.11,21.9 v1(206.04,21.97)
LINE1-VREFO-L: length 2.9
  TOP w0.203: U15.31 205.65,26.8 205.82,26.63 206.55,26.63 206.69,26.77 v1(206.69,27.09)
  BOTTOM w0.508: R465.2 207.32,27.09 v1(206.69,27.09)
LINE1-VREFO-R: length 8.1
  TOP w0.203: v1(206.62,25.86) 206.62,25.96 206.26,26.32 205.7,26.32 205.62,26.4 U15.30
  IN3 w0.508: v1(206.62,25.86) 207.16,25.86 207.55,25.47 207.55,22.48 v1(208.55,21.48)
  BOTTOM w0.508: v1(208.55,21.48) 208.43,21.48 R476.2
LPC_CLKOUT0: length 5.3
  BOTTOM w0.089: U21.AB61 76.45,88.28 76.45,88.77 76.28,88.94 76.01,88.94 75.9,88.83 75.67,88.83 75.57,88.93 74.73,88.93
  BOTTOM w0.114: 74.73,88.93 72.03,88.93 R379.1
LPC_CLKOUT1: length 16.8
  BOTTOM w0.089: U21.AA62 76.01,88.5 75.69,88.5 75.38,88.19 75.12,88.19 75.02,88.09 74.43,88.09 74.29,88.23
  BOTTOM w0.102: 70.32,88.59 70.69,88.59 71.01,88.27 74.26,88.27 74.29,88.23
  BOTTOM w0.127: R376.1 R380.1 63.18,87.57 64.34,87.57 64.65,87.25 v1(67.2,87.25) 67.93,87.25 68.8,88.11 C336.1 69.74,88.59 70.32,88.59
LPC_LAD0: length 239.1
  TOP w0.127: v1(162.53,35.87) 162.06,36.35 161.53,36.35 161.3,36.12 U14.24 ; U16.10 130.68,26.86 130.38,27.16 129.56,27.16 v1(128.89,27.83)
  IN3 w0.127: v1(70.51,91.11) 69.89,91.74 69.89,92.24 68.63,93.5 68.16,93.5 67.94,93.72 64.97,93.72 61.27,90.03 58.75,90.03 58.4,90.38 56.77,90.38 55.67,91.48 49.98,91.48 39.19,80.69 39.19,71.69 37.97,70.47 37.97,60.19 39.14,59.02 39.14,39.1 51,27.23 58.41,27.23 68.58,17.06 82.79,17.06 83.72,17.99 113.14,17.99 114.54,19.39 114.54,21.8 116.57,23.83 118.36,23.83 120.57,26.04 120.57,27.2 121.36,27.99 125.05,27.99 125.5,27.53 127.32,27.53 128.06,28.28 128.44,28.28 v1(128.89,27.83) 128.92,27.83 129.63,27.12 130.75,27.12 131.17,27.54 134.56,27.54 135.38,26.72 136.93,26.72 137.49,26.16 146.67,26.16 146.93,25.9 150.01,25.9 150.5,26.39 152.18,26.39 153.62,27.82 155.95,27.82 v1(156.1,27.97)
  BOTTOM w0.102: R374.2 70.56,91.06 v1(70.51,91.11)
  BOTTOM w0.127: v1(156.1,27.97) 156.1,29.22 156.79,29.91 158.56,29.91 159.86,28.62 159.86,28.61 159.89,28.58 159.9,28.58 159.97,28.5 CN9.64 161.53,28.5 162.11,29.09 162.11,29.74 162.41,30.03 162.41,32.07 162.02,32.45 162.02,33.38 161.68,33.72 161.68,35.02 v1(162.53,35.87)
LPC_LAD0_R: length 5.5
  BOTTOM w0.089: 74.34,89.42 75.07,89.42 75.18,89.31 75.57,89.31 75.67,89.4 75.94,89.4 76.13,89.21 76.44,89.21 U21.Y61
  BOTTOM w0.114: R374.1 72.7,91.06 74.34,89.42
LPC_LAD1: length 246.8
  TOP w0.127: U16.9 132.84,27.26 133.28,26.82 v1(133.28,26.33)
  TOP w0.14: U14.21 161.95,34.62 v1(162.14,34.43)
  IN3 w0.127: v1(72.66,90.51) 71.02,92.14 71.02,93.02 69.31,94.73 64.57,94.73 60.9,91.06 59.18,91.06 58.83,91.41 57.19,91.41 56.1,92.51 49.56,92.51 44.49,87.43 43.47,87.43 37.56,81.52 37.56,79.96 38.17,79.35 38.17,75.73 35.58,73.14 35.58,72.34 36.94,70.99 36.94,59.77 38.15,58.56 38.15,38.63 50.65,26.13 54.2,26.13 55.4,24.93 59.31,24.93 68.21,16.03 83.21,16.03 84.18,17 116.2,17 118.02,18.81 118.02,22.08 122.22,26.28 122.55,26.28 122.81,26.54 128.8,26.54 129.47,25.88 132.83,25.88 v1(133.28,26.33) 134.43,25.17 140.73,25.17 141.72,24.19 145.31,24.19 145.59,24.47 154.01,24.47 v1(156.27,26.72)
  BOTTOM w0.102: v1(72.66,90.51) 71.61,90.51 71.52,90.43 R375.2
  BOTTOM w0.127: v1(156.27,26.72) 156.58,27.03 156.58,29.17 156.9,29.49 158.49,29.49 159.74,28.24 159.74,28.19 159.93,28 CN9.66 161.56,28 162.62,29.06 v1(162.62,29.55) 162.62,29.55 162.75,29.67 162.75,32.21 162.36,32.59 162.36,33.52 162.14,33.75 v1(162.14,34.43)
LPC_LAD1_R: length 4.2
  BOTTOM w0.102: 74.96,89.19 75.03,89.12 U21.Y62
  BOTTOM w0.114: 74.96,89.19 73.51,89.19 72.78,89.92 72.05,89.92 R375.1
LPC_LAD2: length 231.4
  TOP w0.127: U16.8 130.67,27.66 130.41,27.4 129.98,27.4 v1(129.55,27.83) ; U14.18 161.35,33.12 161.55,32.92 162.94,32.92 v1(163.02,32.84)
  IN3 w0.127: v1(157.06,28.73) 156.06,28.73 155.49,28.15 153.48,28.15 152.04,26.72 150.29,26.72 149.8,26.23 147.07,26.23 146.8,26.49 143.87,26.49 143.24,27.12 135.47,27.12 134.72,27.87 131.03,27.87 130.61,27.45 129.93,27.45 v1(129.55,27.83) 128.77,28.61 127.61,28.61 126.53,29.69 125.47,29.69 124.11,28.33 121.21,28.33 120.23,27.34 120.23,26.19 118.3,24.26 116.37,24.26 114.16,22.05 114.16,19.51 112.96,18.32 93.15,18.32 92.45,19.01 85.96,19.01 85.38,18.43 81.49,18.43 80.46,17.4 68.7,17.4 58.54,27.56 51.16,27.56 39.66,39.06 39.66,80.68 50.12,91.13 55.53,91.13 56.62,90.04 58.26,90.04 58.61,89.69 63.29,89.69 v1(63.32,89.71)
  BOTTOM w0.127: v1(63.32,89.71) 63.8,89.71 64.05,89.96 64.05,92.01 64.71,92.67 67.97,92.67 68.08,92.56 R370.2 ; v1(163.02,32.84) 163.09,32.77 163.09,28.92 161.67,27.5 CN9.68 159.66,27.5 159.41,27.75 159.41,28.1 158.78,28.73 v1(157.06,28.73)
LPC_LAD2_R: length 7.6
  BOTTOM w0.089: U21.W62 75.85,89.58 75.64,89.79 75.57,89.85 74.63,89.85 74.4,90.09
  BOTTOM w0.127: R370.1 69.96,92.56 70.57,91.95 72.53,91.95 74.39,90.09 74.4,90.09
LPC_LAD3: length 225.8
  TOP w0.127: v1(158.94,27.95) 159.9,28.91 v1(159.9,29.93) 159.9,30.59 159.22,31.27 U14.15 ; v1(130.2,27.9) 130.2,27.89 130.37,28.06 U16.7
  IN3 w0.127: v1(63.32,89) 62.77,89 62.42,89.34 58.47,89.34 58.12,89.7 56.48,89.7 55.39,90.79 50.28,90.79 39.99,80.5 39.99,39.21 51.31,27.89 58.68,27.89 68.83,17.74 80.32,17.74 81.33,18.76 85.22,18.76 85.82,19.36 92.59,19.36 93.31,18.65 112.79,18.65 113.78,19.64 113.78,22.18 116.22,24.62 118.19,24.62 119.88,26.31 119.88,27.49 121.07,28.67 123.97,28.67 125.33,30.04 126.67,30.04 127.76,28.95 129.15,28.95 v1(130.2,27.9) 130.5,28.2 134.87,28.2 135.61,27.46 145.34,27.46 145.66,27.14 149.22,27.14 149.31,27.05 151.91,27.05 153.34,28.48 155.35,28.48 156.44,29.58 157.91,29.58 158.94,28.55 v1(158.94,27.95)
  BOTTOM w0.127: R372.2 68.65,91.55 67.87,92.33 64.85,92.33 64.39,91.86 64.39,89.54 63.86,89 v1(63.32,89) ; CN9.70 159.5,27 158.94,27.56 v1(158.94,27.95)
LPC_LAD3_R: length 6.5
  BOTTOM w0.127: U21.W63 75.31,89.66 74.49,89.66 72.47,91.68 70.46,91.68 70.32,91.55 R372.1
LPC_LFRAME#: length 241.5
  TOP w0.127: U14.20 161.73,34.12 161.85,34.01 164.18,34.01 165.08,33.11 v1(165.08,31.48) v1(165.08,28.35) ; v1(128.24,27.83) 128.74,28.32 130.38,28.32 130.51,28.46 U16.6
  IN3 w0.127: v1(68.36,93.96) 68.27,94.05 64.83,94.05 61.15,90.37 58.89,90.37 58.54,90.72 56.91,90.72 55.81,91.82 49.84,91.82 38.84,80.82 38.84,71.82 37.62,70.6 37.62,60.05 38.81,58.87 38.81,38.94 50.85,26.9 58.27,26.9 68.46,16.72 82.94,16.72 83.88,17.66 115.89,17.66 117.36,19.12 117.36,22.35 120.91,25.91 120.91,27.06 121.5,27.65 124.9,27.65 125.35,27.2 127.62,27.2 v1(128.24,27.83) 128.26,27.83 128.71,27.38 128.9,27.38 129.51,26.77 130.87,26.77 131.3,27.21 134.23,27.21 135.61,25.83 146.53,25.83 146.81,25.56 150.6,25.56 v1(150.99,25.94) 151.48,25.46 153.2,25.46 153.4,25.66 153.4,26.95 153.94,27.49 159.86,27.49 160.39,28.02 164.75,28.02 v1(165.08,28.35)
  BOTTOM w0.127: R369.2 68.74,93.58 v1(68.36,93.96) ; R464.2 149.8,27.14 v1(150.99,25.94)
LPC_LFRAME#_C: length 3
  BOTTOM w0.127: CN9.73 151.94,26.25 151.65,26.54 v1(151.42,26.54) 151.34,26.54 R464.1
LPC_LFRAME#_R: length 8.3
  BOTTOM w0.089: U21.V61 76.21,90.05 75.93,90.33 75.67,90.33 75.57,90.23 75,90.23 74.53,90.7
  BOTTOM w0.127: R369.1 70.11,93.24 v1(71.33,93.24) 71.99,93.24 74.53,90.7
M_A_A0: length 89.9
  TOP w0.102: v1(58.11,47.63) 57.7,47.22 57.3,47.22 57.15,47.38 56.74,48.11 U8.N3 ; v1(76.01,47.63) 75.61,47.22 75.21,47.22 75.05,47.38 74.64,48.11 U9.N3
  IN2 w0.102: v1(76.01,47.63) 75.61,48.04 75.11,48.04 74.79,48.36 74.48,48.36 74.38,48.26 74.38,47.78 74.28,47.68 74.08,47.68 73.98,47.78 73.98,48.32 73.88,48.43 73.67,48.43 73.57,48.32 73.57,47.78 73.47,47.68 73.27,47.68 73.16,47.78 73.16,48.32 73.06,48.43 72.86,48.43 72.76,48.32 72.76,47.78 72.66,47.68 72.45,47.68 72.35,47.78 72.35,48.13 72.13,48.36 71.57,48.36 71.34,48.58 v1(68.7,48.58) 65.54,48.58 65.3,48.34 64.62,48.34 63.54,47.26 58.48,47.26 v1(58.11,47.63)
  IN3 w0.152: v1(68.7,48.58) 70.03,49.91 70.03,63.19 70.23,63.39 70.23,63.61 70.03,63.81 70.03,63.99 70.28,64.24 70.46,64.24 71.23,63.47 71.41,63.47 71.66,63.72 71.66,63.9 70.97,64.59 70.97,64.77 71.23,65.02 71.41,65.02 71.52,64.9 71.75,64.9 71.93,65.08 72.15,65.08 72.55,64.68 72.73,64.68 72.98,64.93 72.98,65.11 72.57,65.52 72.57,65.73 72.79,65.95 73,65.95 73.28,65.68 73.46,65.68 73.71,65.93 73.71,66.11 73.43,66.38 73.43,66.6 73.71,66.87 73.71,68.66 73.55,68.81 73.13,68.81 73.01,68.94 73.01,69.3 73.13,69.42 73.55,69.42 73.71,69.58 73.71,69.88 73.55,70.03 73.31,70.03 73.19,70.16 73.19,70.46 74.86,72.14 75.96,72.14 76.09,72.27 76.09,72.98 76.21,73.11 76.6,73.11 76.73,72.98 76.73,72.27 76.85,72.14 77.27,72.14 77.4,72.27 77.4,72.7 77.52,72.83 77.88,72.83 78.01,72.7 78.01,72.46 78.14,72.33 78.39,72.33 78.87,72.81 80.15,72.81 v1(80.35,72.62)
  BOTTOM w0.089: v1(80.35,72.62) 80.35,73.19 81.34,74.18 81.34,74.89 81.57,75.11 81.57,75.66 81.68,75.77 81.68,76.09 U21.BG50
  BOTTOM w0.102: U25.N3 77.11,48.68 76.45,48.02 76.45,47.41 76.26,47.21 75.97,47.21 75.84,47.34 75.84,47.46 v1(76.01,47.63) ; v1(58.11,47.63) 57.93,47.46 57.93,47.34 58.06,47.21 58.35,47.21 58.55,47.41 58.55,48.02 59.21,48.68 U24.N3
  BOTTOM w0.152: v1(68.7,48.58) 68.7,47.98 70.34,46.34 70.34,45.02 70.48,44.88 v1(70.48,41.77) 70.48,40.61 R427.2
M_A_A1: length 92.1
  TOP w0.102: v1(57.42,46) 57.83,45.6 58.23,45.6 58.46,45.84 58.46,46.51 U8.P7 ; U9.P7 76.37,46.51 76.37,45.84 76.13,45.6 75.74,45.6 v1(75.33,46)
  TOP w0.152: v1(68.83,46.12) 68.83,46.11 71.36,43.57 R188.2
  IN1 w0.102: v1(79.06,72.28) 79.06,71.81 78.91,71.66 74.85,71.66 74.21,71.03 74.21,69.59
  IN1 w0.127: 74.21,69.59 74.21,69.56 74.21,69.56 74.21,66.29 70.11,62.2 70.11,61.6 69.97,61.46 69.48,61.46 69.35,61.33 69.35,60.98 69.48,60.85 70,60.85 70.12,60.72 70.12,60.47 70,60.34 69.49,60.34 69.36,60.22 69.36,59.96 69.49,59.84 70,59.84 70.12,59.71 70.12,59.45 70,59.33 69.49,59.33 69.36,59.2 69.36,58.95 69.49,58.82 70,58.82 70.12,58.69 70.12,58.44 70,58.31 69.52,58.31 69.38,58.18 69.38,51.31 70.11,50.57 70.11,48.45 68.83,47.16 v1(68.83,46.12)
  IN2 w0.102: v1(75.33,46) 75.28,46 74.94,45.67 74.69,45.67 74.58,45.57 74.58,45.32 74.47,45.21 74.3,45.21 74.18,45.32 74.18,45.57 74.08,45.67 73.87,45.67 73.77,45.57 73.77,45.31 73.65,45.19 73.48,45.19 73.37,45.31 73.37,45.57 73.26,45.67 73.06,45.67 72.96,45.57 72.96,45.31 72.84,45.19 72.67,45.19 72.55,45.31 72.55,45.57 72.45,45.67 72.25,45.67 72.15,45.57 72.15,45.31 72.03,45.19 71.86,45.19 71.74,45.31 71.74,45.57 71.64,45.67 71.43,45.67 71.33,45.57 71.33,45.31 71.21,45.19 71.05,45.19 70.93,45.31 70.93,45.57 70.83,45.67 70.62,45.67 70.52,45.57 70.52,45.31 70.4,45.19 70.23,45.19 70.11,45.31 70.11,45.57 70.01,45.67 69.81,45.67 69.71,45.57 69.71,45.31 69.59,45.19 69.42,45.19 69.3,45.31 69.3,45.64 v1(68.83,46.12) 68.8,46.15 58.77,46.15 58.23,45.6 57.83,45.6 v1(57.42,46)
  BOTTOM w0.089: v1(79.06,72.28) 78.79,72.28 78.51,71.99 ; 79.22,71.28 79.46,71.52 79.46,72.8 80.99,74.33 80.99,75.03 81.2,75.25 81.2,75.67 81.11,75.77 81.11,76 81.39,76.29 U21.BG51
  BOTTOM w0.102: 79.22,71.28 79.12,71.19 78.23,71.19 78.07,71.34 78.07,71.56 78.51,71.99 ; U24.P7 56.02,47.88 55.9,47.77 55.9,47.62 56.04,47.49 56.3,47.49 56.45,47.64 56.61,47.64 56.87,47.38 56.87,47.18 56.74,47.05 56.74,46.8 57.13,46.41 57.44,46.41 57.53,46.32 57.53,46.11 v1(57.42,46) ; v1(75.33,46) 75.44,46.11 75.44,46.32 75.35,46.41 75.04,46.41 74.65,46.8 74.65,47.05 74.78,47.18 74.78,47.38 74.52,47.64 74.36,47.64 74.21,47.49 73.95,47.49 73.81,47.62 73.81,47.77 73.92,47.88 U25.P7
M_A_A2: length 88.2
  TOP w0.102: U8.P3 56.17,47.68 56.81,47.04 56.81,46.75 57.15,46.41 57.65,46.41 v1(58.06,46) ; v1(75.96,46) 75.56,46.41 75.06,46.41 74.72,46.75 74.72,47.04 74.08,47.68 U9.P3
  TOP w0.152: R189.2 v1(72.38,42.38) 72.38,43.64 v1(69.41,46.6)
  IN1 w0.102: v1(79.86,72.17) 79.07,71.38 74.85,71.38 74.54,71.07 74.54,69.34
  IN1 w0.127: 74.54,69.34 74.54,66.19 70.62,62.27 70.62,57.91 70.49,57.78 69.83,57.78 69.71,57.65 69.71,57.4 69.83,57.27 70.49,57.27 70.62,57.14 70.62,56.89 70.49,56.76 69.83,56.76 69.71,56.64 69.71,56.38 69.83,56.26 70.41,56.26 70.54,56.13 70.54,55.87 70.41,55.75 69.83,55.75 69.71,55.62 69.71,55.37 69.83,55.24 70.4,55.24 70.53,55.11 70.53,54.86 70.4,54.73 69.83,54.73 69.71,54.6 69.71,54.35 69.83,54.22 70.32,54.22 70.45,54.1 70.45,53.84 70.32,53.72 69.83,53.72 69.71,53.59 69.71,53.33 69.83,53.21 70.4,53.21 70.52,53.08 70.52,52.83 70.4,52.7 69.81,52.7 69.68,52.57 69.68,52.32 69.81,52.19 70.49,52.19 70.62,52.06 70.62,48.38 69.41,47.18 v1(69.41,46.6)
  IN2 w0.102: v1(58.06,46) 58.4,46.35 67.06,46.35 v1(69.41,46.6) 70.15,45.87 74.75,45.87 74.92,46.04 74.92,46.3 75.04,46.41 76.16,46.41 76.4,46.65 77.65,46.65 77.77,46.53 77.77,46.12 77.66,46 v1(75.96,46)
  BOTTOM w0.089: U21.BH51 81.39,75.19 81.16,74.96 81.16,74.26 79.73,72.82 79.73,72.31 v1(79.86,72.17)
  BOTTOM w0.102: U24.P3 59.53,47.88 59.64,47.77 59.64,47.56 59.49,47.41 59.13,47.41 58.93,47.21 58.93,47 58.57,46.64 58.57,46.52 v1(58.06,46) ; U25.P3 77.43,47.88 77.54,47.77 77.54,47.56 77.39,47.41 77.04,47.41 76.84,47.21 76.84,47 76.48,46.64 76.48,46.52 v1(75.96,46)
M_A_A3: length 97.2
  TOP w0.102: v1(58.06,44.38) 57.65,44.79 57.25,44.79 57.05,44.99 56.5,46.41 56.31,46.61 56.17,46.61 55.84,46.94 55.69,48.02 U8.N2 ; U9.N2 73.6,48.02 73.75,46.94 74.08,46.61 74.21,46.61 74.41,46.41 74.95,44.99 75.16,44.79 75.56,44.79 v1(75.96,44.38)
  IN2 w0.102: v1(75.96,44.38) 75.56,44.79 75.16,44.79 74.96,44.58 74.72,44.58 74.6,44.46 74.6,44.26 74.5,44.16 74.29,44.16 74.19,44.26 74.19,44.48 74.09,44.58 73.89,44.58 73.79,44.48 73.79,44.26 73.68,44.16 73.48,44.16 73.38,44.26 73.38,44.48 73.28,44.58 68.44,44.58 v1(67.69,45.33) 67.25,44.9 61.58,44.9 61.23,44.54 58.22,44.54 v1(58.06,44.38)
  IN3 w0.102: v1(84.52,78.41) 81.58,77.54 80.51,76.69 78.13,76.17 75.69,76.17 74.91,75.4 74.67,75.4
  IN3 w0.152: 74.67,75.4 70.31,71.04 70.31,68.16 68.56,66.41 68.01,66.41 65.29,63.68 65.29,59.08 66.44,57.93 66.44,57.02 65.81,56.4 65.81,51.03 66.25,50 66.58,49.67 67.43,47.75 67.47,47.43 v1(67.69,45.33)
  BOTTOM w0.102: v1(58.06,44.38) 58.31,44.38 58.56,44.63 58.56,45.61 59,46.04 59,46.38 59.23,46.61 59.52,46.61 59.84,46.93 59.84,48.35 U24.N2 ; U21.BD41 85.67,78.41 v1(84.52,78.41) ; U25.N2 77.75,48.35 77.75,46.93 77.43,46.61 77.14,46.61 76.91,46.38 76.91,46.04 76.47,45.61 76.47,44.63 76.22,44.38 v1(75.96,44.38)
  BOTTOM w0.152: v1(67.69,45.33) 67.36,45 67.36,43.31 v1(68.78,41.88) 68.78,40.46 68.43,40.1 67.94,40.1 R425.2
M_A_A4: length 99.6
  TOP w0.102: v1(57.42,41.13) 57.83,41.53 58.23,41.53 58.71,42.01 60,43.42 60.5,44.69 60.5,47.19 U8.P8 ; U9.P8 78.41,47.19 78.41,44.69 77.91,43.42 76.61,42.01 76.13,41.53 75.74,41.53 v1(75.33,41.13)
  TOP w0.152: R185.2 68.31,40.38 v1(67.85,40.85)
  IN2 w0.102: v1(75.33,41.13) 75.09,40.89 74.91,40.89 74.83,40.98 74.83,41.07 74.73,41.17 74.52,41.17 74.42,41.07 74.42,40.88 74.3,40.76 74.13,40.76 74.02,40.88 74.02,41.07 73.91,41.17 73.71,41.17 73.61,41.07 73.61,40.89 73.49,40.77 73.32,40.77 73.2,40.89 73.2,41.07 73.1,41.17 72.9,41.17 72.8,41.07 72.8,40.89 72.68,40.77 72.51,40.77 72.39,40.89 72.39,41.07 72.29,41.17 72.09,41.17 71.98,41.07 71.98,40.89 71.86,40.77 71.7,40.77 71.58,40.89 71.58,41.07 71.48,41.17 71.27,41.17 71.17,41.07 71.17,40.89 71.05,40.77 70.88,40.77 70.76,40.89 70.76,41.07 70.66,41.17 70.46,41.17 70.36,41.07 70.36,40.95 70.26,40.85 v1(67.85,40.85) 67.72,40.72 57.83,40.72 v1(57.42,41.13)
  IN3 w0.102: 80.26,67.11 80.26,67.57 80.77,68.79 81,69.34 81.13,70.02 82.34,73.02 82.86,74.71 v1(84.64,76.82)
  IN3 w0.152: 80.26,67.11 80.26,67.09 80.08,66.3 80.08,66.3 78.71,64.94 77.74,64.94 73.3,60.5 72.29,59.59 71.99,59.35 71.55,58.92 71.55,50.59 71.35,48.76 71.35,48.65 70.81,48.11 70.81,47.72 70.99,47.54 70.99,45.63 v1(67.85,40.85)
  BOTTOM w0.102: U25.P8 72.93,47.88 72.86,47.8 72.86,47.64 73.01,47.49 73.01,47.28 72.86,47.13 72.86,46.88 73.01,46.73 73.01,46.48 72.86,46.33 72.86,45.36 74.69,41.53 75.09,41.13 v1(75.33,41.13) ; U21.BE41 v1(84.64,76.82) ; v1(57.42,41.13) 57.19,41.13 56.78,41.53 54.95,45.36 54.95,46.33 55.1,46.48 55.1,46.73 54.95,46.88 54.95,47.13 55.11,47.28 55.11,47.49 54.95,47.64 54.95,47.8 55.03,47.88 U24.P8
M_A_A5: length 98.2
  TOP w0.102: v1(75.96,41.13) 75.56,40.72 75.16,40.72 74.96,40.92 74.44,42.06 72.95,45.39 72.95,47.19 U9.P2 ; v1(58.06,41.13) 57.65,40.72 57.25,40.72 57.05,40.92 56.53,42.06 55.04,45.39 55.04,47.19 U8.P2
  TOP w0.152: R184.2 67.3,39.47 v1(67.3,41.25)
  IN1 w0.127: v1(67.3,41.25) 68.73,42.68 68.73,44.25 68.24,44.74 68.24,47.07 69.81,48.63 69.81,50.45 69.05,51.21 69.05,61.56 73.24,65.76 73.24,67.51 v1(72.8,67.95)
  IN2 w0.102: v1(75.96,41.13) 75.56,41.53 75.15,41.53 75,41.38 69.8,41.38 69.57,41.15 69.24,41.15 69.01,41.38 68.72,41.38 68.48,41.15 68.13,41.15 67.92,41.36 67.41,41.36 v1(67.3,41.25) 58.18,41.25 v1(58.06,41.13)
  BOTTOM w0.089: 78.32,72.19 79.88,73.47 80.81,74.4 80.81,75.11 U21.BJ52
  BOTTOM w0.102: 78.32,72.19 77.15,71.22 76.81,71.22 ; U25.P2 78.34,47.88 78.5,47.72 78.5,46.04 77.25,42.41 77.01,42.17 76.86,42.17 76.68,42.36 76.51,42.36 76.39,42.24 76.39,42.07 76.63,41.83 76.63,41.55 76.21,41.13 v1(75.96,41.13) ; U24.P2 60.43,47.88 60.59,47.72 60.59,46.04 59.34,42.41 59.1,42.17 58.96,42.17 58.77,42.36 58.6,42.36 58.48,42.24 58.48,42.07 58.72,41.83 58.72,41.55 58.3,41.13 v1(58.06,41.13)
  BOTTOM w0.152: v1(72.8,67.95) 72.8,69.58 74.8,71.22 76.81,71.22
M_A_A6: length 93.1
  TOP w0.102: U9.R8 77.76,46.49 77.61,45.19 76.33,42.54 76.13,42.35 75.74,42.35 v1(75.33,42.75) ; U8.R8 59.86,46.49 59.7,45.19 58.42,42.54 58.23,42.35 57.83,42.35 v1(57.42,42.75)
  TOP w0.152: v1(66.31,42.51) 65.83,42.03 65.83,39.91 R183.2
  IN1 w0.127: v1(66.31,42.51) 66.31,44.55 66.05,44.81 66.05,60.61 69.05,63.61 69.05,63.79 68.91,63.93 68.91,64.11 69.08,64.29 69.26,64.29 69.49,64.07 69.67,64.07 69.85,64.25 69.85,64.43 69.62,64.65 69.62,64.83 69.8,65.01 69.98,65.01 70.21,64.79 70.39,64.79 70.56,64.97 70.56,65.15 70.34,65.37 70.34,65.55 70.52,65.73 70.7,65.73 70.84,65.59 71.02,65.59 71.36,65.93 v1(71.96,65.93)
  IN2 w0.102: v1(75.33,42.75) 75.18,42.6 66.4,42.6 v1(66.31,42.51) 66.15,42.35 57.83,42.35 v1(57.42,42.75)
  BOTTOM w0.089: 77.55,72.95 77.94,72.95 79.26,74.27 79.91,74.27 80.27,74.63 80.27,75.67 80.18,75.77 80.18,76.01 80.47,76.29 U21.BG53
  BOTTOM w0.102: v1(75.33,42.75) 75.33,43.04 75.22,43.15 74.91,43.15 74.71,43.35 74.71,43.66 74.85,43.8 74.85,43.95 74.71,44.09 74.57,44.09 74.45,43.98 74.34,43.98 74.01,44.3 74.01,44.55 74.2,44.75 74.2,44.95 74.11,45.05 73.85,45.05 73.75,45.15 73.75,46.28 73.28,46.75 U25.R8 ; v1(57.42,42.75) 57.42,43.04 57.32,43.15 57.01,43.15 56.8,43.35 56.8,43.66 56.95,43.8 56.95,43.95 56.8,44.09 56.66,44.09 56.55,43.98 56.43,43.98 56.1,44.3 56.1,44.55 56.29,44.75 56.29,44.95 56.2,45.05 55.94,45.05 55.84,45.15 55.84,46.28 55.37,46.75 U24.R8 ; 75.07,72.95 77.55,72.95
  BOTTOM w0.152: 75.07,72.95 73.59,72.95 70.84,70.21 70.84,67.04 v1(71.96,65.93)
M_A_A7: length 92.1
  TOP w0.102: U8.R2 55.7,46.42 55.7,45.48 56.31,44.11 57.25,43.16 57.65,43.16 v1(58.06,42.75) ; v1(75.96,42.75) 75.56,43.16 75.16,43.16 74.21,44.11 73.61,45.48 73.61,46.42 U9.R2
  TOP w0.152: R182.2 65.26,40.22 65.35,40.31 65.35,42.46 v1(65.81,42.92)
  IN2 w0.102: v1(75.96,42.75) 75.56,43.16 75.16,43.16 74.92,42.92 v1(65.81,42.92) 65.32,42.92 65.06,42.66 64.86,42.66 64.76,42.76 64.76,42.92 64.65,43.02 64.45,43.02 64.35,42.92 64.35,42.75 64.25,42.65 64.04,42.65 63.94,42.75 63.94,42.92 63.84,43.02 63.64,43.02 63.54,42.92 63.54,42.75 63.43,42.65 63.23,42.65 63.13,42.75 63.13,42.92 63.03,43.02 62.82,43.02 62.72,42.92 62.72,42.75 62.62,42.65 62.42,42.65 62.32,42.75 62.32,42.92 62.22,43.02 62.01,43.02 61.75,42.75 v1(58.06,42.75)
  IN3 w0.152: v1(65.81,42.92) 66.2,43.31 66.2,44.41 65.16,45.44 65.16,46.66 65.92,47.42 65.92,49.4 64.17,51.15 64.17,53.58 65.15,54.56 65.15,56.67 65.78,57.3 65.78,57.65 64.63,58.8 64.63,63.96 67.74,67.07 68.28,67.07 69.47,68.26 v1(69.47,69.7)
  BOTTOM w0.089: 76.82,73.92 78.11,73.92 79.12,74.93 79.12,75.11 79.29,75.28 79.29,75.68 79.25,75.75 79.22,75.82 79.25,76.01 79.38,76.14 79.54,76.3 U21.BG55
  BOTTOM w0.102: U25.R2 78.08,46.75 77.75,46.42 77.75,46.16 77.41,45.82 77.41,45.48 77.6,45.28 77.6,45.1 76.92,44.42 76.92,43.49 76.18,42.75 v1(75.96,42.75) ; U24.R2 60.17,46.75 59.84,46.42 59.84,46.16 59.5,45.82 59.5,45.48 59.7,45.28 59.7,45.1 59.01,44.42 59.01,43.49 58.27,42.75 v1(58.06,42.75) ; 76.82,73.92 75.76,73.92 75.6,74.08 73.94,74.08
  BOTTOM w0.152: v1(69.47,69.7) 69.36,69.81 69.36,70.41 73.03,74.08 73.94,74.08
M_A_A8: length 92.7
  TOP w0.102: v1(58.06,41.94) 58.14,41.94 59.06,42.86 59.06,43.38 59.27,43.6 59.45,43.6 59.54,43.51 59.7,43.51 59.86,43.67 59.86,44.03 59.81,44.08 59.63,44.08 59.54,44.17 59.54,44.38 59.65,44.49 59.96,44.49 60.17,44.7 U8.T8 ; U9.T8 78.08,44.7 77.87,44.49 77.56,44.49 77.45,44.38 77.45,44.17 77.54,44.08 77.72,44.08 77.77,44.03 77.77,43.67 77.61,43.51 77.44,43.51 77.36,43.6 77.18,43.6 76.97,43.38 76.97,42.86 76.05,41.94 v1(75.96,41.94)
  IN1 w0.127: v1(66.83,42.07) 66.83,42.38 66.82,42.39 66.82,44.5 66.39,44.92 66.39,46.23 68.19,48.03 68.19,50.36 68.44,50.61 68.44,57.3 68.28,57.46 67.61,57.46 67.48,57.59 67.48,57.84 67.61,57.97 68.28,57.97 68.41,58.1 68.41,58.35 68.28,58.48 67.61,58.48 67.48,58.6 67.48,60.86 72.57,65.95 72.57,66.26 v1(72.51,66.32)
  IN2 w0.102: v1(75.96,41.94) 75.56,42.35 75.16,42.35 74.88,42.07 v1(66.83,42.07) 63.07,42.07 62.83,41.83 62.38,41.83 62.14,42.07 61.4,42.07 61.16,41.83 60.7,41.83 60.46,42.07 59.9,42.07 59.67,41.84 58.87,41.84 58.64,42.07 58.18,42.07 v1(58.06,41.94)
  BOTTOM w0.089: U21.BH53 80.45,75.87 80.45,74.55 79.86,73.96 79.34,73.96 77.99,72.61 77.92,72.61
  BOTTOM w0.102: U24.T8 55.37,45.35 56.03,43.94 57,41.79 57.25,41.53 57.65,41.53 v1(58.06,41.94) ; U25.T8 73.28,45.35 73.94,43.94 74.9,41.79 75.16,41.53 75.56,41.53 v1(75.96,41.94) ; 77.09,72.61 77.92,72.61
  BOTTOM w0.152: 77.09,72.61 73.8,72.61 71.38,70.19 71.38,67.45 v1(72.51,66.32) ; R424.2 66.28,40.36 66.83,40.9 v1(66.83,42.07)
M_A_A9: length 86.6
  TOP w0.102: U8.R3 56.49,47.08 56.61,46.96 56.61,46.65 57,46.26 57,45.72 57.13,45.6 57.42,45.6 57.54,45.47 57.54,45.31 v1(57.42,45.19) ; v1(75.33,45.19) 75.45,45.31 75.45,45.47 75.33,45.6 75.04,45.6 74.91,45.72 74.91,46.26 74.52,46.65 74.52,46.96 74.4,47.08 U9.R3
  TOP w0.152: R180.2 63.23,39.86 64.5,41.13 64.5,43.95 v1(65.04,44.49) 66.09,45.54 v1(66.81,45.54)
  IN1 w0.127: v1(66.81,45.54) 66.81,46.07 69.5,48.76 69.5,50.32 68.74,51.08 68.74,58.92 68.62,59.05 67.91,59.05 67.78,59.17 67.78,59.43 67.91,59.55 68.62,59.55 68.74,59.68 68.74,59.94 68.62,60.06 67.95,60.06 67.82,60.19 67.82,60.44 67.95,60.57 68.62,60.57 68.74,60.7 68.74,61.69 69.5,62.45 72.94,65.88 72.94,67.09 v1(72.77,67.26)
  IN2 w0.102: v1(57.42,45.19) 57.83,44.79 61.04,44.79 61.46,45.2 66.48,45.2 v1(66.81,45.54) 67.02,45.74 68.28,45.74 68.37,45.65 68.37,45.51 68.18,45.32 68.18,45.18 68.33,45.03 68.47,45.03 68.66,45.22 68.8,45.22 69.24,44.79 74.64,44.79 75.04,45.19 v1(75.33,45.19)
  BOTTOM w0.089: U21.BG52 80.93,75.94 80.63,75.64 80.63,74.48 79.92,73.76 79.55,73.76 78.15,72.36
  BOTTOM w0.102: U25.R3 77.28,47.04 76.74,46.5 76.29,45.76 76.13,45.6 75.74,45.6 v1(75.33,45.19) ; U24.R3 59.37,47.04 58.84,46.5 58.39,45.76 58.23,45.6 57.83,45.6 v1(57.42,45.19) ; 78.15,72.36 78.05,72.26 75.76,72.26
  BOTTOM w0.152: v1(72.77,67.26) 71.96,68.07 71.96,69.56 71.71,69.8 71.71,70.04 71.95,70.27 72.18,70.27 72.47,69.98 72.65,69.98 72.94,70.27 72.94,70.45 72.65,70.74 72.65,70.97 72.88,71.2 73.11,71.2 73.51,70.8 73.69,70.8 73.98,71.09 73.98,71.27 73.58,71.67 73.58,71.9 73.93,72.25 74.3,72.25 74.45,72.1 74.45,71.76 74.62,71.59 74.95,71.59 75.11,71.76 75.11,72.1 75.28,72.26 75.76,72.26
M_A_A10: length 93.6
  TOP w0.102: v1(76.01,49.26) 76.01,49.41 76.16,49.55 76.33,49.55 76.46,49.43 76.66,49.43 76.77,49.54 76.77,49.84 76.48,50.13 76.48,50.25 76.62,50.39 77.16,50.39 U9.L7 ; v1(58.11,49.26) 58.11,49.41 58.25,49.55 58.6,49.55 58.76,49.71 58.76,49.88 58.51,50.13 58.51,50.3 58.61,50.39 58.89,50.39 59.05,50.54 59.3,50.54 59.37,50.47 U8.L7
  IN2 w0.102: 76.34,49.66 75.07,49.66 74.99,49.58 74.99,49.36 74.91,49.28 74.73,49.28 74.65,49.36 74.65,49.75 74.53,49.87 74.37,49.87 74.25,49.75 74.25,49.38 74.14,49.28 73.94,49.28 73.84,49.38 73.84,49.55 73.72,49.67 73.55,49.67 73.43,49.55 73.43,49.38 73.32,49.27 72.65,49.27 72.3,49.62 72.3,49.72 71.42,50.6 69.22,50.6 v1(68.87,50.25) 64.28,50.25 63.13,49.1 58.27,49.1 v1(58.11,49.26)
  IN2 w0.14: v1(76.01,49.26) 76.13,49.14 76.49,49.14 76.62,49.27 76.62,49.56 76.51,49.66 76.34,49.66
  IN3 w0.152: v1(80.92,71.82) 80.82,71.92 80.82,72.81 80.28,73.35 77.35,73.35 77.13,73.57 75.88,73.57 72.68,70.37 72.68,68.72 73.38,68.02 73.38,67.14 73.03,66.8 72.18,66.8 69.7,64.31 69.7,52.41 69.54,52.26 69.29,52.26 69.17,52.13 69.17,51.77 69.29,51.65 69.54,51.65 69.7,51.49 69.7,51.07 v1(68.87,50.25)
  BOTTOM w0.089: U21.BH49 82.32,74.47 81.98,74.13 81.8,74.13 80.92,73.26 80.92,72.38 81.32,71.98 81.32,71 81.53,70.79 82.85,70.79 82.96,70.68 82.96,70.54 82.85,70.43 80.05,70.43 79.92,70.56 79.92,70.93 80.05,71.06 80.62,71.06 80.75,71.18 80.75,71.65 v1(80.92,71.82)
  BOTTOM w0.102: U24.L7 57.17,48.99 57.3,48.85 57.7,48.85 v1(58.11,49.26) ; v1(76.01,49.26) 75.61,48.85 75.21,48.85 75.07,48.99 U25.L7
  BOTTOM w0.152: v1(68.87,50.25) 69.7,50.25 70.87,49.07 70.87,47.7 71.14,47.43 71.14,46.32 72.38,45.09 v1(72.38,42.03) R430.2
M_A_A11: length 89.8
  TOP w0.102: U9.R7 76.6,46.4 76.6,44.98 76.4,44.79 75.97,44.79 75.84,44.91 75.84,45.07 v1(75.96,45.19) ; U8.R7 58.69,46.4 58.69,44.98 58.49,44.79 58.06,44.79 57.93,44.91 57.93,45.07 v1(58.06,45.19)
  TOP w0.152: v1(65.62,45.74) 64.11,44.23 64.11,41.64 v1(63.3,40.83) 62.22,39.75 R179.2
  IN2 w0.102: v1(75.96,45.19) 75.56,45.6 75.16,45.6 74.55,44.99 69.32,44.99 68.37,45.94 65.82,45.94 v1(65.62,45.74) 61.55,45.74 60.91,45.1 60.65,45.1 60.52,45.23 60.52,45.82 60.4,45.94 60.23,45.94 60.11,45.82 60.11,45.2 60.01,45.1 59.81,45.1 59.7,45.21 59.7,45.82 59.58,45.94 59.42,45.94 59.3,45.82 59.3,45.24 59.2,45.14 58.99,45.14 58.89,45.24 58.89,45.57 58.77,45.69 58.63,45.69 58.14,45.19 v1(58.06,45.19)
  IN3 w0.152: v1(69.85,70.22) 69.93,70.15 69.93,68.25 68.42,66.74 67.88,66.74 64.96,63.82 64.96,58.94 66.11,57.79 66.11,57.16 65.48,56.54 65.48,54.42 64.5,53.44 64.5,53.29 64.66,53.14 65.36,53.14 65.48,53.01 65.48,52.66 65.36,52.53 64.66,52.53 64.5,52.38 64.5,52.09 64.68,51.91 65.36,51.91 65.48,51.78 65.48,51.41 65.36,51.28 65.05,51.28 64.89,51.13 64.88,51.11 64.88,50.91 66.25,49.54 66.25,48.47 67.1,47.62 67.1,47.22 v1(65.62,45.74)
  BOTTOM w0.089: U21.BH55 79.47,75.82 79.47,75.2 79.3,75.03 79.3,74.81 78.04,73.55 76.95,73.55
  BOTTOM w0.102: U25.R7 74.61,46.5 74.95,45 75.16,44.79 75.56,44.79 v1(75.96,45.19) ; v1(58.06,45.19) 57.65,44.79 57.25,44.79 57.04,45 56.7,46.5 U24.R7 ; 75.69,73.55 76.95,73.55
  BOTTOM w0.152: v1(69.85,70.22) 69.85,70.42 73.12,73.69 75.56,73.69 75.69,73.55
M_A_A12: length 88.2
  TOP w0.102: U8.N7 59.21,48.68 58.51,47.99 58.51,47.41 58.29,47.18 58.06,47.18 57.96,47.08 v1(57.96,46.82) ; U9.N7 77.11,48.68 76.42,47.99 76.42,47.41 76.2,47.18 75.97,47.18 75.87,47.08 v1(75.87,46.82)
  TOP w0.152: v1(66.65,47.43) 66.42,47.43 63.71,44.72 63.71,41.97 R178.2
  IN1 w0.127: v1(71.5,65.47) 66.35,60.32 66.35,60.16 66.48,60.04 66.98,60.04 67.1,59.91 67.1,59.66 66.98,59.53 66.48,59.53 66.35,59.4 66.35,59.15 66.48,59.02 66.98,59.02 67.1,58.89 67.1,58.64 66.98,58.51 66.48,58.51 66.35,58.39 66.35,58.13 66.48,58 67.05,58 67.17,57.88 67.17,57.62 67.05,57.5 66.48,57.5 66.35,57.37 66.35,57.12 66.48,56.99 67.77,56.99 67.9,56.86 67.9,56.61 67.77,56.48 66.48,56.48 66.35,56.35 66.35,56.1 66.48,55.97 67.81,55.97 67.94,55.85 67.94,55.59 67.81,55.46 66.48,55.46 66.35,55.34 66.35,47.72 v1(66.65,47.43)
  IN2 w0.102: v1(57.96,46.82) 65.38,46.82 65.65,47.09 65.65,47.58 65.77,47.7 65.94,47.7 66.06,47.58 66.06,47.37 66.17,47.26 66.48,47.26 v1(66.65,47.43) 66.94,47.72 70.42,47.72 70.92,47.22 75.46,47.22 v1(75.87,46.82)
  BOTTOM w0.089: 77.21,73.29 78.03,73.29 79.47,74.73 79.47,74.96 79.65,75.13 79.65,75.56 80,75.92 U21.BG54
  BOTTOM w0.102: v1(75.87,46.82) 75.46,47.22 75.21,47.22 75.05,47.38 U25.N7 ; 74.73,73.29 77.21,73.29 ; U24.N7 57.14,47.38 57.3,47.22 57.55,47.22 v1(57.96,46.82)
  BOTTOM w0.152: 74.73,73.29 73.21,73.29 70.41,70.49 70.41,66.56 71.5,65.47 v1(71.5,65.47)
M_A_A13: length 89.7
  TOP w0.102: U8.T3 56.17,45.63 56.27,45.53 56.52,45.53 56.63,45.42 56.63,45.22 56.53,45.12 56.31,45.12 56.22,45.02 56.22,44.82 56.34,44.69 56.55,44.69 56.69,44.83 56.83,44.83 56.97,44.69 56.97,44.22 57.42,43.77 v1(57.42,43.57) ; v1(75.33,43.57) 75.33,43.77 74.88,44.22 74.88,44.69 74.74,44.83 74.59,44.83 74.46,44.69 74.25,44.69 74.12,44.82 74.12,45.02 74.22,45.12 74.44,45.12 74.54,45.22 74.54,45.42 74.43,45.53 74.18,45.53 74.08,45.63 U9.T3
  TOP w0.152: v1(68.11,43.32) 68.53,43.32 v1(69.45,42.4) 69.45,41.58 69.33,41.46 R186.2
  IN2 w0.102: v1(57.42,43.57) 57.83,43.16 58.23,43.16 58.39,43.32 v1(68.11,43.32) 68.31,43.53 68.52,43.53 68.62,43.43 68.62,43.28 68.72,43.18 68.92,43.18 69.03,43.28 69.03,43.43 69.13,43.53 69.33,43.53 69.43,43.43 69.43,43.28 69.53,43.18 69.74,43.18 69.84,43.28 69.84,43.43 69.94,43.53 70.14,43.53 70.24,43.43 70.24,43.28 70.35,43.18 70.55,43.18 70.65,43.28 70.65,43.43 70.75,43.53 70.96,43.53 71.06,43.43 71.06,43.28 71.16,43.18 71.36,43.18 71.46,43.28 71.46,43.43 71.57,43.53 71.77,43.53 71.87,43.43 71.87,43.28 71.97,43.18 72.17,43.18 72.28,43.28 72.28,43.43 72.38,43.53 72.58,43.53 72.68,43.43 72.68,43.28 72.78,43.18 72.99,43.18 73.09,43.28 73.09,43.43 73.19,43.53 73.39,43.53 73.5,43.43 73.5,43.29 73.6,43.19 73.8,43.19 73.9,43.29 73.9,43.43 74,43.53 74.21,43.53 74.31,43.43 74.31,43.29 74.41,43.19 74.61,43.19 74.71,43.29 74.71,43.43 74.82,43.53 75.14,43.53 75.18,43.57 v1(75.33,43.57)
  IN3 w0.102: v1(80.55,69.88) 80.56,69.06 80.23,68.23 79.85,67.39 79.83,67.21 79.81,67.11
  IN3 w0.152: v1(68.11,43.32) 70.66,45.87 70.66,47.4 70.48,47.58 70.48,48.25 71.02,48.79 71.02,58.95 71.33,59.26 71.33,59.48 71.02,59.79 71.02,59.97 71.27,60.22 71.45,60.22 71.76,59.91 71.97,59.91 72.19,60.12 72.19,60.34 71.68,60.85 71.68,61.03 71.93,61.28 72.11,61.28 72.62,60.77 72.84,60.77 73.05,60.99 73.05,61.2 72.54,61.71 72.54,61.89 72.79,62.15 72.97,62.15 73.48,61.63 73.7,61.63 77.33,65.27 78.4,65.27 79.37,66.24 79.55,66.24 79.68,66.37 79.68,66.41 79.81,67.11
  BOTTOM w0.089: 82.86,70.05 83.42,70.61 83.42,75.17 83.44,75.19 83.44,75.66 83.53,75.75 83.53,76.09 U21.BG46
  BOTTOM w0.102: v1(75.33,43.57) 75.74,43.16 76.13,43.16 76.34,43.37 U25.T3 ; U24.T3 58.43,43.37 58.23,43.16 57.83,43.16 v1(57.42,43.57) ; 82.86,70.05 82.69,69.88 v1(80.55,69.88)
