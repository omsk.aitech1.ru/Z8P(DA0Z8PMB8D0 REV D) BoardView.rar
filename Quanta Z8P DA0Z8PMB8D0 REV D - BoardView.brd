# Allegro board Quanta Z8P DA0Z8PMB8D0 REV D - BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCH_SPI_IO2: length 39.7
  TOP w0.127: U1.3 69.35,126.21 68.17,125.02 v1(68.17,122.47)
  BOTTOM w0.102: U21.B60 77.42,97.78 77.42,98.28 76.92,98.79 76.72,98.79 75.82,99.68 75.63,99.68
  BOTTOM w0.127: 75.63,99.68 71.03,99.68 v1(70.85,99.85) R352.1 69.97,101.08 69.72,101.33 68.34,101.33 67.58,102.09 67.58,104.24 68.38,105.04 68.38,107.49 69.5,108.62 69.5,117.41 68.69,118.23 68.69,121.95 v1(68.17,122.47)
PCH_SPI_IO3: length 38.8
  TOP w0.127: U1.7 70.62,121.09 70.14,121.57 v1(68.18,121.57)
  BOTTOM w0.102: 75.86,99.3 76.74,98.42 76.74,97.7 U21.B61
  BOTTOM w0.127: 75.86,99.3 70.79,99.3 70.32,99.78 R354.1 69.38,99.18 68.52,99.18 v1(67.57,100.13) 66.12,101.58 66.12,102.81 66.97,103.67 66.97,104.35 67.87,105.25 67.87,107.71 69,108.83 69,117.2 68.18,118.02 v1(68.18,121.57)
PCH_SPI_SI: length 33.4
  TOP w0.127: v1(69.19,121.06) 68.31,121.06 68.08,120.83 U1.5
  BOTTOM w0.102: 75.82,99.97 76.75,99.04 77.05,99.04 77.76,98.33 U21.A58
  BOTTOM w0.127: v1(69.19,121.06) 69.19,118.44 70.01,117.62 70.01,108.41 68.89,107.28 68.89,104.83 68.09,104.03 v1(68.09,103.26) 68.09,102.56 68.8,101.84 69.93,101.84 70.32,101.45 70.5,101.45 71.98,99.97 75.82,99.97
PCH_SPI_SI_EC: length 20.6
  TOP w0.14: U16.102 143.48,32.98 143.57,33.08 143.57,39.26 141.26,41.57 v1(141.26,42.86)
  BOTTOM w0.14: U28.5 136.57,37.93 140.14,41.49 140.14,43.18 140.39,43.43 140.68,43.43 v1(141.26,42.86)
PCH_SPI_SO: length 38.9
  TOP w0.127: U1.2 70.62,126.76 69.2,125.34 v1(69.2,123.83)
  BOTTOM w0.102: U21.B58 78.09,97.85 78.09,98.31 77.15,99.24 76.88,99.24 75.89,100.23 75.63,100.23
  BOTTOM w0.127: 75.63,100.23 72.25,100.23 70.14,102.35 68.9,102.35 68.6,102.65 68.6,103.82 v1(69.24,104.46) 69.4,104.62 69.4,107.07 70.52,108.2 70.52,117.83 69.7,118.65 69.7,121.41 69.2,121.91 v1(69.2,123.83)
PCH_SPI_SO_EC: length 16.3
  TOP w0.14: U16.103 143.08,33.03 143.29,33.24 143.29,39.16 141.1,41.36 140.82,41.36 v1(140.59,41.58) v1(140.59,42.85)
  BOTTOM w0.14: U28.2 142.4,40.47 140.59,42.28 v1(140.59,42.85)
PCH_SUSPWRDNACK: length 189
  TOP w0.127: U16.15 132.23,24.86 133.02,25.66 133.91,25.66 134.39,26.15 134.39,27.26 132.6,29.06 v1(132.6,29.06)
  IN2 w0.127: v1(124.95,38.27) 124.88,38.2 124.88,34.38 126.15,33.11 126.72,33.11 128.01,31.83 129.83,31.83 v1(132.6,29.06)
  IN3 w0.127: v1(73.09,87.18) 72.92,87.01 71.12,87.01 70.61,87.52 65.41,87.52 63.84,85.95 62.77,85.95 62.58,85.76 52.31,85.76 51.19,84.64 50.28,84.64 49.27,83.63 49.27,82.78 48.76,82.27 48.76,77.54 49.94,76.36 49.94,74.09 49.35,73.5 49.35,72.29 43.63,66.57 43.63,44.54 44.9,43.27 44.9,39.57 52.87,31.6 97.72,31.6 97.86,31.74 101.4,31.74 102.28,32.61 102.98,32.61 103.85,31.75 107.9,31.75 108.58,32.43 110.72,32.43 111.35,33.06 113.34,33.06 113.69,33.41 117.38,33.41 117.87,33.9 120.42,33.9 120.99,34.47 123.06,34.47 123.98,35.39 124.7,35.39 124.95,35.64 v1(124.95,38.27)
  BOTTOM w0.089: 73.14,87.23 73.64,87.73
  BOTTOM w0.102: 70.63,86.67 72.28,86.67 72.79,87.18 v1(73.09,87.18) 73.14,87.23 ; 73.64,87.73 U21.AC63
  BOTTOM w0.14: R384.1 70.45,86.67 70.63,86.67
PCH_TPD_INT#: length 153.9
  TOP w0.14: v1(129.21,36.85) 128.26,35.91 126.69,35.91 125.91,35.12 125.91,34.68 123.47,32.23 123.47,31.5 122.69,30.73 122.69,28.77 122.11,28.19 121.26,28.19 120.42,27.34 120.42,26.79 117.94,24.32 114.88,24.32 113.72,23.16 110.98,23.16 109.72,21.9 108.62,21.9 108.48,21.76 106.78,21.76 105.91,20.89 105.91,20.5 106.25,20.16 106.58,20.16 106.75,19.99 Q20.6 ; R25.2 85.94,98.97 85.94,98.46 86.93,97.47 86.93,94.18 v1(87.41,93.69)
  IN1 w0.114: v1(129.21,36.85) 129.76,37.41 130.93,37.41 134.52,41 134.52,51 v1(138.3,54.78)
  IN2 w0.14: v1(109.18,101.3) 109.18,100.51 106.8,98.12 93.67,98.12 91.6,96.06 91.6,95.43 91.46,95.28 90.68,95.28 89.09,93.69 v1(87.41,93.69)
  IN3 w0.127: v1(138.3,54.78) 135.79,54.78 128.65,61.91 128.65,77.77 127.04,79.38 127.04,88.39 124.41,91.03 123.65,91.03 121.16,93.52 121.16,95.43 114.44,102.15 110.03,102.15 v1(109.18,101.3)
  BOTTOM w0.102: v1(87.41,93.69) 87.31,93.69 U21.J39
PCH_VDDEN: length 12.1
  BOTTOM w0.102: 79.92,102.98 79.92,102.79 79.8,102.67 79.8,102.35 v1(79.41,101.96) 79.8,101.57 79.8,100.8 80.98,99.61 82.39,99.61 83.27,98.74 83.27,98.52 83.28,98.51 83.28,98.35 83.33,98.3 83.33,98.04 83.54,97.84 83.54,97.59 83.25,97.3 U21.C47
  BOTTOM w0.14: 79.92,102.98 79.92,104.09 79.7,104.31 78.85,104.31 78.73,104.18 Q27.5
PCI_PLTRST#: length 18.9
  TOP w0.14: Q5.3 62.84,85.81 63.12,85.53 v1(63.49,85.53) 70.93,85.53 71.83,86.43 73.89,86.43 74.53,87.07 75.51,87.07 C70.1 76.24,86.33 78.52,86.33 v1(78.96,85.89)
  BOTTOM w0.102: v1(78.96,85.89) 78.96,85.97 78.65,86.28 U21.AG57
PCIE_CLKREQ_WLAN#: length 210
  TOP w0.127: v1(169.73,32.99) Q35.6 167.99,32.99 167.01,33.98 U29.3
  IN1 w0.102: v1(149.69,37.8) 149.88,37.8 153,40.92 164.71,40.92 170.42,35.21 170.42,33.68 v1(169.73,32.99) ; v1(66.47,84.22) 64.06,81.81 64.06,80.22 61.19,77.35 61.19,75.51 59.87,74.2 58.33,74.2 47.66,63.53 45.55,63.53 42.52,60.5 42.52,49.92 v1(50,42.44)
  IN3 w0.127: v1(149.69,37.8) 147.18,37.8 146.53,38.45 135.64,38.45 134.4,39.69 133.74,39.69 133.44,39.39 132.01,39.39 130.32,41.07 129.38,41.07 127.98,42.47 119.18,42.47 115.83,39.12 115.83,38.13 114.92,37.22 114.23,37.22 113.74,36.73 104.88,36.73 104.78,36.83 97.01,36.83 95.97,35.79 91.05,35.79 90.26,36.58 80.22,36.58 79.46,35.83 55.59,35.83 50,41.41 v1(50,42.44)
  BOTTOM w0.102: 74.5,85.89 74.97,85.89 75.23,86.15 75.55,86.15 75.85,85.85 75.85,85.77 76.16,85.45 U21.AJ62 ; 70.32,84.05 70.73,83.65 71.72,83.65 R486.2
  BOTTOM w0.127: 70.32,84.05 69.9,84.47 68.27,84.47 R392.2 66.91,85.33 66.91,84.84 66.47,84.4 v1(66.47,84.22) ; 74.5,85.89 72.76,84.16 R486.2
PCIE_LAN_WAKE#: length 113.6
  TOP w0.127: Q15.4 33.28,27.53 33.82,28.07 v1(36.33,28.07)
  IN2 w0.127: v1(37.67,57.65) 37.67,56.11 37.88,55.89 37.88,47.9 34.82,44.84 v1(33.77,44.84)
  IN3 w0.127: v1(69.68,94.98) 69.59,95.06 64.44,95.06 60.77,91.4 59.32,91.4 58.97,91.75 57.33,91.75 56.24,92.85 49.4,92.85 44.31,87.76 43.33,87.76 37.22,81.65 37.22,79.83 37.84,79.21 37.84,75.88 35.25,73.3 35.25,59.85 36.44,58.67 36.64,58.67 v1(37.67,57.65) ; v1(36.33,28.07) 36.97,28.07 37.55,28.66 37.55,32.08 36.97,32.67 36.97,36.63 33.77,39.83 v1(33.77,44.84)
  BOTTOM w0.102: 70.32,95.1 71.08,94.34 73.16,94.34 73.51,93.99 73.51,93.57 75.31,91.78 75.47,91.78 75.54,91.72 75.56,91.72 75.66,91.61 75.91,91.61 75.92,91.62 75.93,91.62 76.21,91.9 U21.P61
  BOTTOM w0.127: R366.1 70.29,95.26 70.29,95.13 70.32,95.1
  BOTTOM w0.14: v1(69.68,94.98) 69.68,95.3 R366.1
PCIE_LAN_WAKE#_R: length 29.6
  TOP w0.127: v1(32.18,43.38) 33.13,44.33 v1(34.23,44.33) ; Q15.3 35.63,27.53 v1(35.83,27.34)
  TOP w0.14: U13.39 29.58,39.23 31.7,41.35 R168.2 31.7,42.9 v1(32.18,43.38)
  IN3 w0.127: v1(35.83,27.34) 36.64,27.34 37.83,28.53 37.83,32.16 37.22,32.77 37.22,36.73 34.02,39.93 34.02,44.12 v1(34.23,44.33)
PCIE_RCOMPN: length 3.8
  TOP w0.127: R37.2 100.66,96.86 100.66,96.73 100.81,96.58 102.3,96.58 102.54,96.34 102.54,95.97 102.62,95.9 v1(102.86,95.9)
  BOTTOM w0.127: v1(102.86,95.9) 103.2,95.55 U21.F5
PCIE_RCOMPP: length 3.9
  TOP w0.127: R37.1 100.41,96.89 100.41,96.63 100.7,96.33 102.2,96.33 102.29,96.24 102.29,95.93 102.2,95.84 v1(101.99,95.84)
  BOTTOM w0.127: v1(101.99,95.84) 102.33,95.5 U21.F6
PCIE_RX0+_SSD: length 72.1
  TOP w0.127: v1(47.4,102.72) 47.26,102.72 47.1,102.88 47.1,103.05 47.44,103.39 52.27,103.39 55.48,106.6 64.59,106.6 65.99,105.2 72.87,105.2 73.97,104.09 82.45,104.09 83.48,103.06 92.04,103.06 94.24,100.86 94.94,100.86 95.6,100.2 96.49,100.2 97.38,99.31 97.38,98.01 98.78,96.61 99.22,96.61 99.77,96.06 99.77,95.67 100.66,94.78 102.24,94.78 102.53,94.49 102.53,94.13 102.17,93.77 102.17,93.14 102.42,92.88 102.42,92.72 v1(102.12,92.43)
  BOTTOM w0.102: U21.P7 101.78,92.08 v1(102.12,92.43)
  BOTTOM w0.127: v1(47.4,102.72) 47.2,102.72 47.09,102.61 47.09,100.34 46.19,99.44 46.19,98.46 46.35,98.31 R359.2
PCIE_RX0-_SSD: length 72.1
  TOP w0.127: v1(46.64,102.72) 46.85,102.93 46.85,103.16 47.34,103.65 52.16,103.65 55.37,106.85 64.7,106.85 66.1,105.45 72.97,105.45 74.08,104.34 82.55,104.34 83.59,103.31 92.15,103.31 94.34,101.12 95.04,101.12 95.71,100.45 96.59,100.45 97.63,99.41 97.63,98.12 98.89,96.86 99.33,96.86 100.03,96.16 100.03,95.78 100.77,95.04 102.34,95.04 102.79,94.59 102.79,94.03 102.42,93.66 102.42,93.24 102.67,92.99 102.67,92.59 v1(102.83,92.43)
  BOTTOM w0.102: v1(102.83,92.43) 102.49,92.08 U21.P6
  BOTTOM w0.127: v1(46.64,102.72) 46.84,102.52 46.84,100.44 45.94,99.55 45.94,98.5 R358.2
PCIE_RX1+_SSD: length 69
  TOP w0.127: v1(43.98,102.07) 44.24,101.81 51.67,101.81 55.54,105.67 64.56,105.67 65.68,104.56 72.6,104.56 73.77,103.39 82.16,103.39 83.13,102.42 91.17,102.42 93.37,100.23 94.68,100.23 95.4,99.5 96.24,99.5 96.68,99.06 96.68,97.78 98.87,95.58 98.87,93.82 99.49,93.21 99.49,92.31 99.81,91.99 100.2,91.99 100.69,91.5 v1(100.69,91.45)
  BOTTOM w0.102: U21.T10 100.69,91.4 v1(100.69,91.45)
  BOTTOM w0.127: R333.2 42.51,101.79 43.18,101.79 43.3,101.91 43.82,101.91 v1(43.98,102.07)
PCIE_RX1+_SSD_R: length 11.4
  BOTTOM w0.127: CN5.31 33.68,97.74 33.82,97.88 33.82,98.11 34.1,98.4 37.32,98.4 38.34,99.42 38.34,100.1 39.43,101.19 39.91,101.19 v1(40.42,101.7) 40.8,101.32 40.9,101.32 41.15,101.56 41.44,101.56 41.53,101.65 R333.1
PCIE_RX1-_SSD: length 69
  TOP w0.127: v1(43.98,101.41) 44.12,101.56 51.78,101.56 55.64,105.42 64.46,105.42 65.57,104.31 72.5,104.31 73.67,103.14 82.05,103.14 83.02,102.17 91.07,102.17 93.26,99.97 94.57,99.97 95.3,99.25 96.13,99.25 96.42,98.96 96.42,97.67 98.62,95.48 98.62,93.72 99.23,93.1 99.23,92.2 99.98,91.45 v1(99.98,91.45)
  BOTTOM w0.102: v1(99.98,91.45) 100.05,91.38 100.05,91.11 99.93,91 99.71,91 U21.T12
  BOTTOM w0.127: v1(43.98,101.41) 43.73,101.66 43.41,101.66 43.28,101.53 42.47,101.53 42.31,101.37 R351.2
PCIE_RX1-_SSD_R: length 11.4
  BOTTOM w0.127: CN5.29 34.18,97.78 34.07,97.89 34.07,98.01 34.21,98.14 37.43,98.14 38.6,99.32 38.6,100 39.53,100.93 39.92,100.93 v1(40.42,100.43) 40.42,100.87 40.61,101.06 41.01,101.06 41.25,101.31 41.44,101.31 41.53,101.22 R351.1
PCIE_RX2+_LAN: length 163.6
  TOP w0.127: C224.2 32.15,30.64 32.25,30.54 32.25,30.16 v1(31.93,29.84)
  IN1 w0.102: v1(103.48,93.43) 103.25,93.66 103.25,93.89 104.89,95.53 107.05,95.53 110.31,92.27 111.49,92.27 112.57,91.19 112.57,89.69 121.66,80.61 121.66,67.97 123.65,65.98 123.65,50.76 122.61,49.72 122.61,46 115.73,39.13 115.73,38.05 115.15,37.46 114.07,37.46 112.73,36.13 38.29,36.13 36.99,34.84 36.99,34.23 33.95,31.18 32.55,31.18 32.18,30.81 32.18,29.88 32.13,29.84 v1(31.93,29.84)
  BOTTOM w0.102: U21.M5 103.2,93.28 103.34,93.43 v1(103.48,93.43)
PCIE_RX2+_LAN_C: length 3.2
  TOP w0.127: U13.25 31.85,33.31 32.25,32.91 32.25,31.41 32.13,31.29 31.9,31.29 C224.1
PCIE_RX2-_LAN: length 163.6
  TOP w0.127: v1(32.59,29.84) 32.51,29.92 32.51,30.42 C225.2
  IN1 w0.102: v1(102.85,93.48) 103.04,93.68 103.04,93.98 104.81,95.74 107.13,95.74 110.39,92.48 111.58,92.48 112.77,91.28 112.77,89.78 121.86,80.69 121.86,68.05 123.85,66.07 123.85,50.68 122.81,49.64 122.81,45.92 115.94,39.05 115.94,37.96 115.23,37.26 114.15,37.26 112.82,35.93 38.37,35.93 37.2,34.75 37.2,34.14 34.03,30.98 32.64,30.98 32.38,30.72 32.38,30.04 v1(32.59,29.84)
  BOTTOM w0.102: U21.M6 102.49,93.12 v1(102.85,93.48)
PCIE_RX2-_LAN_C: length 3.2
  TOP w0.127: U13.26 31.77,33.71 32.48,33.01 32.48,31.67 C225.1
PCIE_RX3+_WLAN: length 103.5
  IN3 w0.089: v1(99.96,92.48) 100.14,92.48 100.2,92.54 100.2,92.83 100.5,93.13 100.97,93.13 101.1,93 104.31,93 104.35,93.04 104.37,93.04
  IN3 w0.127: v1(156.27,44) 156.04,43.78 154.29,43.78 150.98,47.09 149.64,47.09 149.22,47.51 141.76,47.51 141.27,48 137.62,48 132.4,53.21 131.55,53.21 125.66,59.1 125.66,77.3 121.52,81.44 121.52,85.4 115.66,91.26 113.46,91.26 112.22,92.49 108.72,92.49 107.76,93.45 105.14,93.45 104.73,93.04 104.37,93.04
  BOTTOM w0.102: U21.P12 99.96,92.26 v1(99.96,92.48)
  BOTTOM w0.127: v1(156.27,44) 156.08,43.81 155.83,43.81 155.42,43.4 155.42,37.25 155.15,36.99 155.15,34.65 154.63,34.13 154.17,34.13 154.05,34.25 CN9.41
PCIE_RX3-_WLAN: length 103.4
  IN3 w0.089: 104.37,92.79 104.35,92.79 104.31,92.83 101.03,92.83 100.9,92.95 100.58,92.95 100.38,92.75 100.38,92.54 100.49,92.43 v1(100.67,92.43)
  IN3 w0.127: 104.37,92.79 104.84,92.79 105.25,93.2 107.66,93.2 108.61,92.24 112.12,92.24 113.35,91 115.56,91 121.26,85.3 121.26,81.34 125.4,77.2 125.4,59 131.44,52.96 132.3,52.96 137.51,47.74 141.16,47.74 141.65,47.25 149.11,47.25 149.53,46.83 150.88,46.83 154.18,43.53 156.08,43.53 v1(156.27,43.34)
  BOTTOM w0.102: v1(100.67,92.43) 100.48,92.43 100.29,92.24 100.29,92 U21.P10
  BOTTOM w0.127: CN9.43 154.05,33.75 154.17,33.87 154.74,33.87 155.41,34.55 155.41,36.89 155.67,37.15 155.67,43.29 155.94,43.56 156.05,43.56 v1(156.27,43.34)
PCIE_TX0+_SSD: length 104.3
  IN1 w0.102: v1(114.82,92.61) 114.67,92.76 113.34,92.76 112.54,93.56 112.54,96.31 110.38,98.46 108.28,98.46 107.21,99.53 105.18,99.53 104.98,99.73 103.2,99.73 100.73,102.2 96.5,102.2 89.89,108.81 87.88,108.81 86.7,109.99 84.17,109.99 82.3,111.86 79.27,111.86 77.27,109.86 74.47,109.86 72.8,108.19 63.6,108.19 62.64,109.15 61.92,109.15 60.96,108.19 48.78,108.19 46.06,105.47 46.06,105.04 v1(46.18,104.92)
  BOTTOM w0.102: U21.V3 104.19,90.05 104.5,89.74 104.73,89.74 104.83,89.84 104.85,89.84 104.87,89.86 105.09,89.86 105.65,90.42 107.45,90.42 108.05,89.82 110.02,89.82 110.04,89.79 110.07,89.79
  BOTTOM w0.127: v1(114.82,92.61) 114.62,92.81 114.4,92.81 111.38,89.79 110.07,89.79 ; C324.2 49.12,98.31 48.89,98.54 48.89,102.72 47.76,103.84 46.32,103.84 45.99,104.17 45.99,104.73 v1(46.18,104.92)
PCIE_TX0-_SSD: length 104.3
  IN1 w0.102: v1(114.89,93.26) 114.6,92.96 113.43,92.96 112.74,93.65 112.74,96.39 110.46,98.67 108.37,98.67 107.3,99.74 105.26,99.74 105.07,99.93 103.28,99.93 100.81,102.4 96.58,102.4 89.98,109.01 87.97,109.01 86.79,110.19 84.26,110.19 82.39,112.06 79.19,112.06 77.19,110.06 74.38,110.06 72.71,108.39 63.69,108.39 62.72,109.35 61.84,109.35 60.87,108.39 48.7,108.39 45.86,105.55 45.86,105.17 45.61,104.92 v1(45.52,104.92)
  BOTTOM w0.102: U21.V2 104.77,90.05 104.79,90.06 105.01,90.06 105.57,90.62 107.53,90.62 108.13,90.02 110.02,90.02 110.04,90.05 110.07,90.05
  BOTTOM w0.127: 110.07,90.05 111.28,90.05 114.29,93.06 114.7,93.06 v1(114.89,93.26) ; C323.2 48.52,98.31 48.63,98.42 48.63,102.61 47.66,103.59 46.21,103.59 45.74,104.06 45.74,104.73 45.74,104.74 45.74,104.85 45.67,104.92 v1(45.52,104.92)
PCIE_TX1+_SSD: length 96.5
  IN1 w0.102: v1(114.03,93.89) 113.82,94.1 113.82,96.48 110.81,99.49 109.05,99.49 107.77,100.77 103.88,100.77 101.42,103.23 96.91,103.23 90.31,109.82 88.3,109.82 87.11,111.02 84.6,111.02 82.74,112.87 78.83,112.87 76.83,110.87 74.05,110.87 72.88,109.7 66.92,109.7 66.65,109.98 63.53,109.98 63.14,110.37 60.71,110.37 59.82,109.48 48.51,109.48 44.49,105.45 44.49,104.69 44.31,104.52 44.19,104.52 v1(43.96,104.74)
  BOTTOM w0.089: 105.6,91.52 105.59,91.53 105.11,91.53 U21.R1
  BOTTOM w0.102: 105.6,91.52 107.01,91.52 107.74,92.25 110.02,92.25 110.04,92.22 110.07,92.22
  BOTTOM w0.127: 110.07,92.22 111.44,92.22 111.86,92.65 112.97,92.65 113.81,93.5 113.81,93.66 v1(114.03,93.89) ; v1(43.96,104.74) 43.74,104.53 43.34,104.53 42.63,103.82 42.45,103.82 42.31,103.96 C312.2
PCIE_TX1+_SSD_C: length 14.9
  BOTTOM w0.127: C312.1 41.53,103.96 41.41,103.84 40.85,103.84 v1(40.35,104.35) 40.01,104.01 39.77,104.01 38.97,103.21 38.97,101.99 37.46,100.47 37.46,99.79 37.02,99.36 33.21,99.36 32.29,98.43 32.29,97.89 32.18,97.78 CN5.37
PCIE_TX1-_SSD: length 96.5
  IN1 w0.102: v1(113.39,93.89) 113.62,94.12 113.62,96.39 110.72,99.29 108.96,99.29 107.69,100.56 103.79,100.56 101.33,103.02 96.82,103.02 90.23,109.62 88.22,109.62 87.03,110.81 84.51,110.81 82.66,112.67 78.92,112.67 76.92,110.67 74.13,110.67 72.96,109.5 66.84,109.5 66.57,109.77 63.45,109.77 63.06,110.16 60.79,110.16 59.9,109.27 48.6,109.27 44.69,105.36 44.69,104.61 44.4,104.31 44.19,104.31 v1(43.96,104.08)
  BOTTOM w0.089: U21.R2 104.35,91.55 104.69,91.55 104.85,91.71 105.57,91.71 105.59,91.72
  BOTTOM w0.102: 110.07,92.48 110.04,92.48 110.02,92.45 107.65,92.45 106.92,91.72 105.59,91.72
  BOTTOM w0.127: v1(113.39,93.89) 113.56,93.71 113.56,93.6 112.86,92.91 111.76,92.91 111.33,92.48 110.07,92.48 ; v1(43.96,104.08) 43.77,104.27 43.44,104.27 42.74,103.57 42.5,103.57 42.31,103.37 C314.2
PCIE_TX1-_SSD_C: length 14.9
  BOTTOM w0.127: C314.1 41.53,103.47 41.41,103.59 40.86,103.59 v1(40.35,103.08) 40.35,103.48 40.07,103.75 39.87,103.75 39.23,103.11 39.23,101.88 37.71,100.37 37.71,99.68 37.13,99.1 33.32,99.1 32.54,98.33 32.54,97.91 32.68,97.78 CN5.35
PCIE_TX2+: length 4.8
  BOTTOM w0.102: C335.1 108.65,90.91 108.65,91.06 108.54,91.16 107.9,91.16 107.7,90.95 104.63,90.95 U21.T2
PCIE_TX2+_LAN: length 155.8
  TOP w0.127: U13.21 29.18,31.92 29.68,31.42 29.68,30.05 29.58,29.95 v1(29.46,29.95)
  IN1 w0.102: v1(29.46,29.95) 29.62,29.95 29.72,30.05 29.72,31.46 30.31,32.06 33.56,32.06 35.5,34 35.5,34.51 37.94,36.96 112.39,36.96 119.88,44.44 119.88,48.16 122.82,51.1 122.82,65.64 120.85,67.62 120.85,80.25 111.75,89.35 111.75,90.85 111.48,91.12 111.25,91.12 v1(111.03,90.9)
  BOTTOM w0.127: v1(111.03,90.9) 110.81,91.13 110.66,91.13 110.53,91 109.51,91 C335.2
PCIE_TX2-: length 4.8
  BOTTOM w0.102: U21.T3 104.42,91.19 104.49,91.26 104.74,91.26 104.85,91.16 107.61,91.16 107.82,91.36 108.13,91.36 C334.1
PCIE_TX2-_LAN: length 155.8
  TOP w0.127: U13.22 29.58,31.84 29.91,31.52 29.91,30.16 v1(30.12,29.95)
  IN1 w0.102: v1(30.12,29.95) 29.92,30.15 29.92,31.38 30.4,31.86 33.64,31.86 35.7,33.91 35.7,34.42 38.03,36.75 112.48,36.75 120.08,44.35 120.08,48.07 123.02,51.02 123.02,65.72 121.05,67.7 121.05,80.34 111.95,89.43 111.95,90.94 111.56,91.32 111.27,91.32 v1(111.03,91.56)
  BOTTOM w0.127: v1(111.03,91.56) 110.85,91.38 110.55,91.38 110.43,91.25 109.42,91.25 C334.2
PCIE_TX3+: length 5.8
  BOTTOM w0.089: 105.4,92.28 105.2,92.09 104.85,92.09 104.75,92.19 104.5,92.19 104.44,92.13 U21.P3
  BOTTOM w0.102: 105.4,92.28 106.6,92.28 108.24,93.92 108.48,93.92 C332.1
PCIE_TX3+_WLAN: length 93.1
  IN3 w0.127: v1(111.31,94.26) 111.51,94.06 112.27,94.06 114.17,92.16 116.02,92.16 121.65,86.53 122.26,86.53 123.96,84.83 123.96,80.28 126.56,77.67 126.56,59.47 131.93,54.1 133.28,54.1 138.14,49.24 141.3,49.24 142.13,48.41 149.59,48.41 150.01,47.99 151.36,47.99 153.8,45.55 156.17,45.55 v1(156.3,45.67)
  BOTTOM w0.127: v1(111.31,94.26) 111.09,94.05 110.75,94.05 110.42,93.71 109.66,93.71 109.45,93.92 C332.2 ; v1(156.3,45.67) 156.08,45.46 155.83,45.46 155.56,45.19 155.56,44.79 154.51,43.74 154.51,37.66 154.27,37.42 154.27,35.69 154.19,35.62 154.06,35.62 153.93,35.75 CN9.35
PCIE_TX3-: length 5.8
  BOTTOM w0.089: U21.P2 104.62,91.91 105.31,91.91 105.48,92.08
  BOTTOM w0.102: 105.48,92.08 106.69,92.08 108.33,93.72 108.91,93.72 108.99,93.63 108.99,93.48 C333.1
PCIE_TX3-_WLAN: length 93
  IN3 w0.127: v1(156.3,45.01) 156.01,45.29 153.7,45.29 151.25,47.73 149.91,47.73 149.49,48.16 142.02,48.16 141.19,48.99 138.03,48.99 133.18,53.85 131.82,53.85 126.31,59.36 126.31,77.57 123.7,80.17 123.7,84.73 122.16,86.28 121.54,86.28 115.91,91.9 114.07,91.9 112.17,93.81 111.51,93.81 v1(111.31,93.6)
  BOTTOM w0.127: v1(111.31,93.6) 111.31,93.73 111.24,93.8 110.86,93.8 110.53,93.46 109.75,93.46 C333.2 ; v1(156.3,45.01) 156.11,45.2 155.93,45.2 155.82,45.08 155.82,44.68 154.76,43.63 154.76,37.56 154.52,37.31 154.52,35.59 154.29,35.36 154.06,35.36 153.95,35.25 CN9.37
PCLK_TPM: length 195.3
  TOP w0.127: U14.19 161.41,33.62 161.55,33.48 v1(163.02,33.48)
  IN3 w0.127: v1(50.63,85.78) 49.67,85.78 47.61,83.72 47.61,79.43 46.81,78.63 46.81,77.67 48.77,75.7 48.77,74.54 48.21,73.97 48.21,72.76 42.48,67.04 42.48,40.33 52.39,30.43 98.2,30.43 98.34,30.57 104.48,30.57 104.86,30.19 107.25,30.19 107.63,30.57 108.89,30.57 109.35,31.03 110.94,31.03 111.82,31.91 112.19,31.91 112.46,31.64 119.04,31.64 120.07,32.67 122.88,32.67 124.45,34.24 127.6,34.24 128.94,32.91 129.67,32.91 130.16,32.41 133.75,32.41 134.75,31.42 141.22,31.42 141.75,31.94 146.29,31.94 146.72,31.51 151.74,31.51 154.15,33.93 162.58,33.93 v1(163.02,33.48)
  BOTTOM w0.127: R376.2 59.58,89.74 55.62,85.78 v1(50.63,85.78)
PD#: length 12.8
  TOP w0.14: R232.2 195.5,31.7 v1(195.86,32.06) 196.25,31.67 R228.1 C219.1 197.57,31.22 198.4,30.4 199.89,30.4 200.09,30.2 U15.47
  BOTTOM w0.127: D21.2 198.69,34.46 197.42,33.19 197.42,32.64 v1(197.29,32.52) 197.29,31.68 196.89,31.27 D22.2 196.65,31.27 v1(195.86,32.06)
PHASE_A: length 8.2
  TOP w0.508: PR5.1 95.65,133.44 v2(96.04,133.82)
  BOTTOM w0.254: PR121.2 98.48,124.03 98.2,123.76 95.38,123.76 94.6,124.54 PL4.1
  vias: v1(97.83,134.35)
PHASE_C: length 49.8
  BOTTOM w0.203: PR91.2 111.83,134.18 110.56,135.46 103.48,135.46 100.08,138.87 85.38,138.87 84.19,137.67 84.19,127.59 82.92,126.32 77.81,126.32 77.33,126.8 PL2.1
  vias: v1(74.93,128.24) v1(74.95,128.89) v1(75.91,128.94)
PLTRST#: length 267.2
  TOP w0.127: U16.22 132.43,22.06 133.51,23.14 134.26,23.14 135.23,24.1 135.23,24.57 134.98,24.82 133.7,24.82 133.29,24.42 v1(133.29,24.08)
  TOP w0.14: v1(161.87,31.94) C221.2 162.86,32.23 162.47,32.62 U14.17 ; Q5.1 59.8,85.41 59.42,85.8 R66.2 57.12,85.8 57,85.68 D2.1 56.15,85.01 v1(57.3,83.86) ; U13.30 31.77,35.31 32.44,34.64 32.91,34.64 33.72,33.84 33.93,33.84 C212.1 34.08,33.42 v1(33.59,33.42)
  IN1 w0.102: v1(161.87,31.94) 159.68,29.75 158.19,29.75 157.08,30.86 156.67,30.86 155.56,29.75 152.96,29.75 151.58,28.37 149.33,28.37 149.05,28.09 148,28.09 144.47,24.57 141.8,24.57 141.6,24.77 133.5,24.77 133.29,24.56 v1(133.29,24.08) 133.29,24.09 131.99,24.09 129.6,26.48 122.99,26.48 122.31,25.81 121.78,25.81 118.04,22.06 118.04,19.95 115.06,16.98 84.19,16.98 83.4,16.19 68.32,16.19 59.21,25.3 56.17,25.3 53.41,28.06 38.57,28.06 38.02,28.61 v1(34.02,28.61)
  IN1 w0.114: v1(29.4,87.29) 29.92,87.81 32.02,87.81 34.81,85.02 46.62,85.02 47.29,84.34 56.37,84.34 56.86,83.86 v1(57.3,83.86)
  IN3 w0.127: v1(29.4,87.29) 27.16,85.04 27.16,75.49 26.74,75.07 26.74,70.68 26.25,70.19 25.5,70.19 24.62,69.31 24.62,57.07 24.71,56.99 24.71,47.76 27.6,44.87 29.72,44.87 31.24,43.35 31.24,40.11 33.47,37.88 33.47,33.54 v1(33.59,33.42) 34.02,32.99 v1(34.02,28.61)
  BOTTOM w0.127: CN5.50 28.93,88.59 29.4,88.12 v1(29.4,87.29) ; v1(161.87,31.94) 161.43,31.5 CN9.52
  BOTTOM w0.14: C425.1 132.67,24.7 v1(133.29,24.08)
PMU_RCOMP: length 4.6
  TOP w0.127: v1(76.78,85.87) 76.78,85.69 76.39,85.29 75.83,85.29 75.52,85.6 73.62,85.6 R73.2
  BOTTOM w0.102: v1(76.78,85.87) 77.19,86.28 U21.AG59
PMU_RSTBTN#: length 6.5
  BOTTOM w0.102: 70.32,85.73 70.85,86.26 TP36.1 72.38,86.26 72.89,86.77 73.95,86.77 74.45,87.27 75.78,87.27 U21.AD62
  BOTTOM w0.14: R389.1 70.27,85.68 70.32,85.73
PMU_SLP_S0#: length 6.8
  BOTTOM w0.102: U21.AD61 76.38,87.1 76.05,87.1 75.9,86.95 75.68,86.95 75.55,87.08 74.6,87.08 73.97,86.44 73.31,86.44 72.72,85.86 71.35,85.86 70.9,85.41 TP38.1
PMU_SUSCLK: length 4.7
  BOTTOM w0.102: TP37.1 72.53,85.1 73.57,86.14 74.92,86.14 75.26,86.47 75.5,86.47 75.66,86.63 76,86.63 U21.AE62
PMU_WAKE#: length 11.3
  TOP w0.127: v1(79.66,85.88) 78.74,86.8 76.47,86.8 75.97,87.3 74.43,87.3 73.79,86.66 71.35,86.66 v1(70.9,86.21) 70.75,86.06 R71.2
  BOTTOM w0.102: v1(79.66,85.88) 79.33,86.21 U21.AG55
PROCHOT_EC: length 14.5
  TOP w0.127: U16.17 132.18,24.06 133.53,25.42 134.06,25.42 134.67,26.03 134.67,28.31 132.08,30.9 130.74,30.9 R233.2
  TOP w0.14: Q17.2 129.3,32.74 v1(129.6,32.44) 129.6,32.05 R233.2
PWM_A: length 25.7
  BOTTOM w0.254: PR104.1 111.45,129.37 111.45,133.39 110.26,134.57 103.08,134.57 99.77,137.88 v1(95.9,137.88) 95.79,137.98 93.03,137.98 92.69,137.64 PR84.2
PWM_C: length 56.1
  BOTTOM w0.254: PR112.1 119.8,126.87 119.8,130.03 120.52,130.75 120.52,132.95 119.65,133.81 116.43,133.81 113.89,136.35 103.63,136.35 100.35,139.64 78.79,139.64 v1(77.91,138.77) 77.02,138.77 76.05,137.79 PR85.2
PWRLED#: length 98.5
  TOP w0.127: v1(134.2,22.37) 133.88,22.37 132.77,21.26 U16.24
  IN3 w0.127: v1(212.01,13.37) 211.82,13.18 188.33,13.18 181.43,20.08 174.43,20.08 171.56,22.94 154.49,22.94 152.45,20.9 147.16,20.9 146.18,21.89 140.8,21.89 139.95,22.74 134.62,22.74 134.25,22.37 v1(134.2,22.37)
  BOTTOM w0.14: CN17.8 220.35,17.55 219.91,17.11 219.91,16.23 216.6,12.92 212.47,12.92 v1(212.01,13.37)
R_SPK+: length 17.5
  TOP w0.203: U15.45 200.89,30.34 200.25,30.98 199.88,30.98 v1(199.73,31.13)
  TOP w0.508: v1(199.73,31.13) 199.71,31.16 v1(199.71,31.78)
  IN1 w1.016: 192.18,22.98 190.55,24.6 190.55,27.13 193.04,29.62 197.95,29.62 199,30.66
  vias: v1(192.46,21.99) v1(192.46,21.3)
R_SPK-: length 22.4
  TOP w0.203: v1(200.65,31.27) 200.65,31.01 201.29,30.37 U15.44
  TOP w0.508: v1(200.65,31.93) v1(200.65,31.27)
  IN1 w1.016: 191.15,20.09 193.07,20.09 194.04,21.05 194.04,23.09 191.95,25.18 191.95,26.55 193.62,28.22 198.89,28.22 200.44,29.77 200.44,30.18
  vias: v1(191.07,21.95) v1(191.1,21.29)
RAM_ID0: length 9
  BOTTOM w0.102: U21.C31 90.66,97.3 90.37,97.59 90.37,97.84 90.64,98.11 90.64,99.01 91.47,99.84 92.51,99.84 92.67,99.99 93.9,99.99 95.26,101.35 R350.2 R330.1
RAM_ID1: length 22
  IN2 w0.127: v1(91.7,99.21) 91.7,100.11 88.28,103.53 88.28,108.77 88.91,109.39 92.79,109.39 v1(93.45,110.05)
  BOTTOM w0.102: v1(91.7,99.21) 91.7,98.25 91.28,97.83 91.28,97.61 91.59,97.3 U21.C29
  BOTTOM w0.127: R293.1 R285.2 93.69,108.66 93.25,109.09 93.25,109.85 v1(93.45,110.05)
RAM_ID2: length 6.3
  BOTTOM w0.102: U21.B37 87.9,97.73 87.9,99.45 88.99,100.54 88.99,101.53 R340.2 89.55,102.98
  BOTTOM w0.127: R317.1 89.55,102.98
RAM_ID3: length 26.6
  IN2 w0.127: v1(92.81,110.05) 92.43,110.43 91.67,110.43 91.17,110.93 89.37,110.93 87.52,109.08 87.52,103.21 89.94,100.79 89.94,99.84 89.1,99 89.1,98.45 87.65,97.01 87.65,95.93 88.32,95.26 v1(88.32,94.49)
  BOTTOM w0.102: U21.H35 88.62,94.79 v1(88.32,94.49)
  BOTTOM w0.127: R292.1 R284.2 92.56,108.66 93,109.09 93,109.86 v1(92.81,110.05)
RAM_ID4: length 8.2
  BOTTOM w0.102: U21.C37 87.88,97.29 88.22,97.63 88.3,97.63 88.71,98.04 88.71,99.45 90.18,100.92 90.76,100.92 90.91,101.07 90.91,101.55 90.51,101.96 R338.2 90.51,102.98
  BOTTOM w0.127: R318.1 90.51,102.98
RAM_ID5: length 26.8
  IN2 w0.127: v1(89.3,95.2) 89.98,95.88 89.98,95.89 92.55,98.46 92.55,99.62 88.54,103.63 88.54,108.66 89.01,109.13 94.11,109.13 94.85,109.88 v1(94.85,110.06)
  BOTTOM w0.102: U21.F34 89.6,95.5 v1(89.3,95.2)
  BOTTOM w0.127: R294.1 R286.2 95.1,109.1 95.1,109.81 94.86,110.06 v1(94.85,110.06)
REGOUT:
  vias: v1(32.73,38.89)
RF_EN: length 23.3
  TOP w0.127: R269.2 150.13,15.87 150.13,17.2 150.59,17.65 v1(151.08,17.65) 151.22,17.79 151.22,18.28 151.55,18.61 151.55,19.72 152.92,21.1 152.92,23.04 153.84,23.96 153.84,26.16 154.32,26.65 v1(154.32,26.71)
  BOTTOM w0.127: CN9.56 159.07,30.5 158.76,30.81 155.69,30.81 154.99,30.11 154.99,27.37 v1(154.32,26.71)
RING2: length 1.9
  TOP w0.203: v1(200.84,21.82) v1(200.84,22.48) 201.29,22.93 U15.17
  vias: v1(210.04,19.23) v1(210.2,19.92) v1(210.7,19.23)
RSET: length 3.6
  TOP w0.203: U13.47 26.38,39.15 25.99,39.54 25.11,39.54 v1(24.65,40.01) 24.36,40.29 R173.2
RSMRST#: length 188
  TOP w0.102: R210.1 139.69,33.98 C449.1 v1(139.28,33.33) 139.48,33.13 U16.112
  TOP w0.127: v1(63.56,86.46) 63.71,86.31 v1(65.31,86.31) 66.84,86.31 R67.1 67.01,86.5 67.32,86.82 68,86.82 68.23,87.04 70.24,87.04 71.26,88.05 74.11,88.05 74.31,87.85 76.06,87.85 76.65,87.27 78.46,87.27 v1(78.98,87.78)
  IN3 w0.127: v1(63.56,86.46) 62.1,86.46 61.91,86.26 52.1,86.26 50.98,85.15 49.95,85.15 48.25,83.45 48.25,79.16 47.44,78.35 47.44,77.93 49.42,75.96 49.42,74.29 48.84,73.71 48.84,72.5 43.12,66.78 43.12,44.31 44.38,43.05 44.38,39.36 52.67,31.06 97.93,31.06 98.08,31.21 104.73,31.21 105.12,30.82 106.98,30.82 107.36,31.2 108.63,31.2 109.35,31.92 110.93,31.92 111.56,32.55 112.45,32.55 112.73,32.28 116.97,32.28 118.08,33.39 120.63,33.39 121.2,33.96 123.27,33.96 124.19,34.88 126.48,34.88 127.44,35.84 128.47,35.84 129.24,35.07 129.31,35 130.35,35 130.48,34.87 130.64,34.87 130.69,34.83 131.17,34.83 131.89,34.1 134.44,34.1 135.43,33.11 139.05,33.11 v1(139.28,33.33)
  BOTTOM w0.102: v1(78.98,87.78) 78.62,87.43 U21.AC57
RTC_RST#: length 238.8
  TOP w0.127: v1(184.95,24.2) 185.33,24.2 185.35,24.18 185.96,24.18 v1(186.65,24.87) 187.02,25.24 C253.1 R245.2 ; v1(132.63,40.23) 131.57,41.29 130.84,41.29 129.12,43.01 120.38,43.01 116.37,39 114.97,39 113.47,37.5 103.33,37.5 102.07,36.24 52.9,36.24 47.86,41.29 47.86,45.39 42.99,50.26 42.99,53.36 45.11,55.49 45.11,62.68 52.3,69.87 Q11.6 52.3,71.03 52.62,71.35 57.46,71.35 57.77,71.66 57.77,76.5 58.99,77.71 58.99,81.83 57.95,82.87 57.95,83.65 58.3,84 60.46,84 60.65,84.19 60.65,86.24 61.73,87.32 67.7,87.32 67.94,87.56 70.12,87.56 70.84,88.28 74.2,88.28 74.41,88.08 76.41,88.08 C50.1 77.15,88.2 79.29,88.2 v1(79.72,87.77)
  IN3 w0.127: v1(184.95,24.2) 179.89,24.2 167.78,36.31 155.22,36.31 154.82,35.91 151.81,35.91 151.39,35.91 150.33,36.97 150.33,38.12 149.37,39.08 136.13,39.08 134.59,40.62 133.03,40.62 v1(132.63,40.23)
  BOTTOM w0.102: v1(79.72,87.77) 79.33,87.39 U21.AC55
  BOTTOM w0.127: v1(184.95,24.2) 185.33,24.2 186.13,23.4 J1.1
RTC_TEST#: length 249.3
  TOP w0.127: R246.2 C254.1 190.83,25.24 191.25,24.82 191.25,24.11 190.76,23.63 185.69,23.63 v1(185.23,23.17) ; v1(52.51,75.56) 52.2,75.25 52.2,74.01 51,72.81 Q11.3
  IN3 w0.127: v1(185.23,23.17) 185.03,23.17 185.02,23.17 179.28,23.17 170.44,32.01 169.36,32.01 167.88,33.48 165.1,33.48 163.69,34.89 153.68,34.89 152.91,34.13 149.54,34.13 148.81,34.86 146.52,34.86 146.01,35.37 138.29,35.37 137.65,36.01 132.59,36.01 131.19,37.41 129.37,37.41 128.96,37.82 127.11,37.82 124.65,40.28 120.07,40.28 118.38,38.59 118.38,37.04 115.76,34.42 113.28,34.42 113.14,34.57 109.28,34.57 107.47,32.76 104.27,32.76 103.4,33.63 101.86,33.63 100.99,32.76 97.44,32.76 97.29,32.61 53.35,32.61 46.64,39.32 46.64,42.98 44.64,44.98 44.64,64.8 45.82,65.98 45.82,66.39 52.51,73.07 v1(52.51,75.56) 52.51,76.2 50.42,78.29 50.42,81.58 50.92,82.08 50.92,82.36 52.91,84.35 59.73,84.35 60.95,83.13 67.56,83.13 68.49,84.06 69.95,84.06 70.69,84.8 73.33,84.8 73.95,85.43 81.44,85.43 v1(81.84,85.03)
  BOTTOM w0.102: v1(81.84,85.03) 82.18,85.37 U21.AH49
RTC_X1: length 11.9
  TOP w0.127: Y1.1 67.24,88.8 67.71,89.27 C47.2 68.18,89.52 68.83,89.52 R60.1 v1(69.86,89.3)
  IN3 w0.127: v1(69.86,89.3) 70.18,88.98 70.98,88.98 71.89,88.07 74.19,88.07 74.42,87.84 76.67,87.84 v1(76.82,87.69)
  BOTTOM w0.102: U21.AC59 77.19,87.32 v1(76.82,87.69)
RTC_X2: length 13.2
  TOP w0.127: Y1.2 67.56,90.27 C34.2 68.04,90.16 68.97,90.16 R60.2 v1(69.86,90.08)
  IN3 w0.127: v1(77.59,87.75) 77.09,88.24 76.16,88.24 76,88.08 74.52,88.08 73.97,88.63 71.96,88.63 71.08,89.51 70.43,89.51 v1(69.86,90.08)
  BOTTOM w0.102: U21.AC58 77.91,87.43 v1(77.59,87.75)
S5_ON: length 320.3
  TOP w0.203: v1(140.29,23.92) 140.29,23.73 139.71,23.14 138.62,23.14 138,22.52 138,20.08 138.72,19.36 144.31,19.36 144.94,19.99 145.99,19.99 146.32,19.66 U16.69 147.92,19.66 148.07,19.51 148.12,19.51 148.17,19.46 148.69,19.46 149.08,19.07 R265.1
  TOP w0.254: v1(140.29,23.92) 140.29,24.14 138.24,26.19 138.24,26.95 139.42,28.13 v1(139.42,29.12)
  IN1 w0.254: v1(139.42,29.12) 140.28,28.26 145.6,28.26 146.41,29.07 146.41,31.77 145.49,32.68 145.49,39.33 147.08,40.92 147.08,42.7 146.78,43 146.78,44.25 148.64,46.12 148.64,49.22 147.42,50.45 147.42,60.63 145.96,62.09 145.52,62.09 v1(144.66,62.95)
  IN3 w0.254: v1(140.29,23.92) 140.29,23.86 139.55,23.12 133.95,23.12 133.77,22.93 130.58,22.93 128,25.52 123.23,25.52 122.97,25.25 122.65,25.25 119.05,21.65 119.05,16.34 118.67,15.97 84.6,15.97 81.6,12.97 42.37,12.97 41.79,13.54 41.79,17.61 41.36,18.04 41.36,24.13 42.35,25.11 42.35,27.88 41.14,29.09 v1(39.71,29.09) ; v1(144.66,62.95) 145.33,63.63 146.55,63.63 148.92,66 148.92,81.97 148.09,82.8 148.09,85.05 142.45,90.69 135.06,90.69 131.53,94.23 131.53,108.47 130.34,109.65 130.34,110.95 127.41,113.88 123.93,113.88 123.68,114.12 123.68,114.89 v1(124.34,115.55)
  BOTTOM w0.254: PR136.2 v1(124.34,115.55) ; PR172.2 144.39,62.68 v1(144.66,62.95) ; PR170.2 49.14,73.49 48.83,73.18 46.67,73.18 39.91,66.42 39.91,29.29 v1(39.71,29.09)
SATA_DEVSLP0: length 190.2
  IN3 w0.127: v1(227.99,32.8) 227.31,32.8 225.39,34.73 220.77,34.73 220.15,35.35 216.3,35.35 215.27,36.38 215.27,39.94 214.44,40.77 195.19,40.77 191.76,37.34 191.76,33.67 188.55,30.46 184.89,30.46 172.7,42.65 170.27,42.65 163.38,49.54 151.43,49.54 147.72,53.24 140.49,53.24 140.49,53.26 140.46,53.26 138.49,55.23 135.7,55.23 128.91,62.02 128.91,77.88 127.3,79.49 127.3,88.5 124.52,91.28 123.76,91.28 121.41,93.62 121.41,96.31 109.69,108.03 v1(107.43,108.03)
  IN3 w0.14: v1(227.99,32.8) 229.7,31.09 v1(229.7,29.28)
  BOTTOM w0.127: v1(229.7,29.28) 229.53,29.45 CN11.3 ; CN12.1 227.64,32.45 v1(227.99,32.8) ; R289.1 107.43,107.64 v1(107.43,108.03) 107.43,108.16 107.56,108.29 107.81,108.29 108.05,108.05 Q25.6
SATA_DEVSLP1: length 101.7
  TOP w0.14: R70.2 32.88,86.6 32.39,87.1 v1(32.01,87.1)
  IN1 w0.102: v1(103.71,106.72) 103.71,109.24 102.14,110.81 88.18,110.81 87.35,111.64 84.86,111.64 83,113.5 78.57,113.5 76.56,111.48 73.79,111.48 72.62,110.31 67.18,110.31 66.9,110.59 63.8,110.59 63.38,111 59.59,111 58.68,110.1 47.61,110.1 45.91,108.4 v1(45.91,108.08)
  IN3 w0.127: v1(31.93,92.21) 32.17,91.98 34.2,91.98 38.58,96.35 42.66,96.35 45.66,99.36 45.66,102.81 46.93,104.07 46.93,107.07 v1(45.91,108.08)
  BOTTOM w0.127: Q24.6 104.49,107.92 104.28,108.13 103.33,108.13 R300.1 103.71,107.06 v1(103.71,106.72) ; v1(32.01,87.1) 32.01,87.92 31.93,88 CN5.38
  BOTTOM w0.14: v1(31.93,92.21) CN5.38
SATA_RXN0: length 146.1
  TOP w0.127: v1(193.71,37.7) 193.48,37.47 193.48,36.9 194.21,36.16 199.17,36.16 199.64,36.64 200.64,36.64 C193.1
  IN3 w0.089: v1(102.14,91.44) 101.91,91.44 101.79,91.56 101.79,91.74 101.89,91.84 104.41,91.84 104.45,91.8 104.47,91.8
  IN3 w0.127: v1(193.71,37.7) 193.48,37.46 193.48,34.13 188.92,29.57 184.52,29.57 172.44,41.65 156.16,41.65 155.17,42.64 153.8,42.64 150.5,45.93 149.16,45.93 148.74,46.35 141.25,46.35 140.75,46.85 137.14,46.85 132.03,51.97 131.16,51.97 124.5,58.62 124.5,76.82 120.36,80.96 120.36,84.4 114.92,89.84 109.71,89.84 107.75,91.8 104.47,91.8
  BOTTOM w0.102: U21.T7 101.78,91.29 101.92,91.44 v1(102.14,91.44)
SATA_RXN0_C: length 2.3
  TOP w0.127: C193.2 201.81,36.78 201.96,36.64 202.14,36.64 202.69,37.19 202.97,37.19 203.08,37.3 U12.4
SATA_RXN0_CN: length 32.8
  TOP w0.127: v1(208.53,37.18) 208.63,37.08 C191.1
  IN3 w0.127: v1(228.84,24.67) 228.66,24.84 228.38,24.84 228,25.23 228,25.71 228.18,25.89 228.18,26.59 226.98,27.79 226.98,28.59 226.09,29.49 226.09,29.88 223.65,32.31 219.77,32.31 219.15,32.93 213.98,32.93 211.43,35.48 209.45,35.48 209.23,35.26 208.21,35.26 207.73,35.74 207.73,36.54 208.01,36.83 208.36,36.83 208.53,37 v1(208.53,37.18)
  BOTTOM w0.127: v1(228.84,24.67) 228.68,24.82 228.2,24.82 227.98,25.04 227.46,25.04 227.37,24.95 CN12.16
SATA_RXN0_M2: length 26.3
  TOP w0.127: v1(213.48,36.75) 213.68,36.55 213.68,36.34 213.49,36.15 212.03,36.15 211.73,36.45 211.05,36.45 210.91,36.59 C192.1
  IN3 w0.127: v1(213.48,36.75) 213.69,36.54 213.69,36.06 214.38,35.37 215.02,35.37 215.93,34.46 219.78,34.46 220.4,33.84 224.99,33.84 228.58,30.25 228.58,28.59 229.07,28.1 229.58,28.1 v1(229.74,27.94)
  BOTTOM w0.127: CN11.6 229.3,27.95 229.41,28.06 229.61,28.06 v1(229.74,27.94)
SATA_RXN0_RD: length 3.6
  TOP w0.127: C191.2 210.12,36.69 209.95,36.52 209.11,36.52 208.9,36.73 208.33,36.73 208.04,37.01 208.04,37.13 207.88,37.3 U12.12
SATA_RXN1: length 67.6
  IN1 w0.089: v1(102.84,91.43) 103.07,91.43 103.17,91.53 103.17,91.73 103.05,91.85 99.62,91.85 99.25,92.22 99.25,93.45 99.12,93.58 99.1,93.58 99.09,93.6
  IN1 w0.102: v1(46.89,95.93) 46.32,95.93 46.23,96.02 46.23,96.47 47.62,97.87 49.66,97.87 54.23,102.43 63.01,102.43 64.18,101.26 68.67,101.26 70.59,99.34 79.34,99.34 79.59,99.1 88.81,99.1 89.92,97.98 93.83,97.98 94.25,97.57 95.12,97.57 99.09,93.6
  BOTTOM w0.102: v1(102.84,91.43) 102.49,91.07 U21.T6
  BOTTOM w0.127: R362.2 v1(46.89,95.93)
SATA_RXN1_R: length 21.1
  BOTTOM w0.127: CN5.43 30.68,95.67 32.39,93.96 42.97,93.96 43.48,94.47 44.16,94.47 v1(44.52,94.11) 44.83,94.42 45.61,94.42 46.44,95.24 46.44,97.09 R362.1
SATA_RXP0: length 146
  TOP w0.127: C197.1 200.58,36.38 199.75,36.38 199.27,35.91 194.11,35.91 193.23,36.79 193.23,37.52 v1(193.05,37.7)
  IN3 w0.089: 104.47,92.05 104.45,92.05 104.41,92.02 101.82,92.02 101.62,91.82 101.62,91.66 v1(101.4,91.45)
  IN3 w0.127: 104.47,92.05 107.86,92.05 109.82,90.1 115.02,90.1 120.62,84.5 120.62,81.07 124.76,76.93 124.76,58.73 131.27,52.22 132.14,52.22 137.25,47.11 140.85,47.11 141.36,46.61 148.84,46.61 149.26,46.19 150.61,46.19 153.9,42.89 155.27,42.89 156.26,41.9 172.55,41.9 184.62,29.83 188.81,29.83 193.22,34.24 193.22,37.53 v1(193.05,37.7)
  BOTTOM w0.102: v1(101.4,91.45) 101.07,91.11 U21.T9
SATA_RXP0_C: length 2.4
  TOP w0.127: U12.5 203.05,36.8 202.94,36.91 202.81,36.91 202.26,36.36 201.99,36.36 201.81,36.18 C197.2
SATA_RXP0_CN: length 32.8
  TOP w0.127: v1(208.52,36.05) 208.95,35.62 C199.1
  IN3 w0.127: v1(228.84,25.38) 228.84,25.22 228.72,25.1 228.49,25.1 228.26,25.33 228.26,25.61 228.43,25.79 228.43,26.7 227.23,27.9 227.23,28.7 226.34,29.59 226.34,29.98 223.76,32.57 219.87,32.57 219.25,33.19 214.09,33.19 211.54,35.73 209.35,35.73 209.12,35.51 208.31,35.51 207.98,35.84 207.98,36.44 208.12,36.57 208.47,36.57 208.63,36.42 208.63,36.16 v1(208.52,36.05)
  BOTTOM w0.127: v1(228.84,25.38) 228.84,25.2 228.72,25.08 228.3,25.08 228.08,25.3 227.53,25.3 227.37,25.45 CN12.15
SATA_RXP0_M2: length 26.3
  TOP w0.127: v1(214.14,36.75) 213.94,36.55 213.94,36.23 213.6,35.9 211.92,35.9 211.62,36.2 211.05,36.2 210.95,36.1 C198.1
  IN3 w0.127: v1(214.14,36.75) 213.95,36.55 213.95,36.17 214.49,35.63 215.12,35.63 216.04,34.71 219.89,34.71 220.5,34.09 225.09,34.09 228.83,30.35 228.83,28.69 229.17,28.35 229.5,28.35 v1(229.74,28.58)
  BOTTOM w0.127: CN11.5 229.27,28.45 229.37,28.34 229.49,28.34 v1(229.74,28.58)
SATA_RXP0_RD: length 3.6
  TOP w0.127: U12.11 207.9,36.8 208.22,36.48 208.8,36.48 209,36.27 209.97,36.27 210.17,36.07 C198.2
SATA_RXP1: length 67.6
  IN1 w0.089: 99.23,93.74 99.25,93.72 99.25,93.71 99.43,93.53 99.43,92.3 99.7,92.03 103.13,92.03 103.34,91.81 103.34,91.66 v1(103.57,91.44)
  IN1 w0.102: 99.23,93.74 95.2,97.77 94.34,97.77 93.92,98.19 90.01,98.19 88.89,99.3 79.67,99.3 79.42,99.55 70.67,99.55 68.75,101.47 64.27,101.47 63.09,102.64 54.15,102.64 49.58,98.07 47.53,98.07 46.02,96.56 46.02,96.21 v1(45.74,95.93)
  BOTTOM w0.102: v1(103.57,91.44) U21.T5
  BOTTOM w0.127: R361.2 v1(45.74,95.93)
SATA_RXP1_R: length 21.1
  BOTTOM w0.127: CN5.41 31.18,96.19 30.93,95.94 30.93,95.78 32.5,94.21 42.86,94.21 43.38,94.73 43.86,94.73 v1(44.52,95.38) 44.52,94.94 44.79,94.67 45.51,94.67 46.18,95.35 46.18,97.44 46.1,97.53 R358.1
SATA_TXN0: length 144.1
  TOP w0.127: C185.1 201.03,38.42 200.85,38.6 198.83,38.6 198.11,37.87 196.85,37.87 v1(196.63,37.65)
  IN3 w0.127: v1(107.48,87.87) 107.25,87.87 107.09,88.04 107.09,88.28 107.22,88.41 107.83,88.41 108.19,88.04 114.2,88.04 118.56,83.69 118.56,80.21 122.7,76.07 122.7,56.72 130.6,48.81 132.63,48.81 136.87,44.57 147.97,44.57 149.07,43.48 150.41,43.48 153.02,40.86 154.43,40.86 155.42,39.87 171.68,39.87 183.76,27.8 189.66,27.8 195.8,33.94 195.8,37.51 196.18,37.88 196.5,37.88 196.63,37.76 v1(196.63,37.65)
  BOTTOM w0.089: 105.49,88.94 105.31,89.12 U21.Y2
  BOTTOM w0.102: v1(107.48,87.87) 107.21,87.87 107.08,88 107.08,88.45 106.6,88.94 105.49,88.94
SATA_TXN0_C: length 2
  TOP w0.127: U12.2 203,38.3 202.81,38.48 202.24,38.48 C185.2
SATA_TXN0_CN: length 36.5
  TOP w0.127: C184.1 208.72,38.61 v1(208.53,38.43)
  IN3 w0.127: v1(208.53,38.43) 208.75,38.64 208.75,39.2 208.58,39.37 208.14,39.37 207.17,38.4 207.17,35.58 208.16,34.58 211.61,34.58 214.38,31.82 217.6,31.82 218.16,32.37 218.99,32.37 219.56,31.81 223.27,31.81 223.55,31.52 225.57,29.51 225.57,29.29 226.46,28.4 226.46,27.58 226.78,27.26 226.78,26.06 226.95,25.89 226.95,23.7 227.12,23.53 227.53,23.53 227.72,23.73 v1(227.72,23.87)
  BOTTOM w0.127: v1(227.72,23.87) 227.64,23.95 CN12.18
SATA_TXN0_M2: length 30
  TOP w0.127: R203.2 210.92,39.31 211.01,39.4 211.21,39.4 v1(211.62,38.99)
  IN3 w0.127: v1(229.7,27.13) 229.45,26.88 229.35,26.88 228,28.23 228,29.04 227.37,29.67 227.37,30.72 224.76,33.33 220.19,33.33 219.57,33.95 214.4,33.95 210.63,37.72 210.63,38.96 210.94,39.27 211.42,39.27 211.62,39.07 v1(211.62,38.99)
  BOTTOM w0.127: v1(229.7,27.13) 229.52,26.95 CN11.8
SATA_TXN0_RD: length 3.7
  TOP w0.127: R203.1 210.14,39.04 210.05,39.13 208.59,39.13 208.08,38.62 208.08,38.48 207.9,38.3 U12.14
SATA_TXN1: length 71.3
  IN1 w0.102: v1(106.49,89.86) 106.27,90.08 106.27,90.44 105.77,90.95 98.66,90.95 97.65,91.95 97.65,92.79 97.27,93.17 97.27,94.46 94.68,97.05 94.07,97.05 93.62,97.5 89.64,97.5 89.02,98.12 77.95,98.12 77.64,98.43 75.78,98.43 75.56,98.21 71.02,98.21 68.59,100.64 63.44,100.64 62.14,101.94 54.44,101.94 49.73,97.23 48.95,97.23 48.41,96.69 48.41,96.18 v1(48.16,95.93)
  BOTTOM w0.089: U21.W2 104.73,89.42 104.84,89.31 105.37,89.31 105.46,89.22 105.55,89.22
  BOTTOM w0.102: v1(106.49,89.86) 106.29,89.67 106.29,89.47 106.04,89.22 105.55,89.22
  BOTTOM w0.127: C325.2 v1(48.16,95.93)
SATA_TXN1_C: length 26.8
  BOTTOM w0.127: C323.1 48.43,97.53 48.59,97.36 48.59,95.59 48.78,95.4 48.78,95.12 48.69,95.03 48.5,95.03 v1(48.12,94.64) 48.52,94.64 48.77,94.39 48.77,93.86 48.2,93.28 32.03,93.28 29.43,95.88 29.43,96 29.68,96.25 CN5.47
SATA_TXP0: length 144.1
  TOP w0.127: C183.1 200.81,38.85 198.73,38.85 198,38.13 196.81,38.13 v1(196.63,38.31)
  IN3 w0.127: v1(196.63,38.31) 196.45,38.14 196.07,38.14 195.54,37.61 195.54,34.04 189.55,28.05 183.86,28.05 171.79,40.12 155.53,40.12 154.54,41.11 153.13,41.11 150.51,43.73 149.18,43.73 148.08,44.83 136.98,44.83 132.74,49.07 130.71,49.07 122.95,56.82 122.95,76.18 118.81,80.32 118.81,83.79 114.31,88.3 108.3,88.3 107.93,88.66 107.11,88.66 106.83,88.38 106.83,88.02 v1(106.69,87.87)
  BOTTOM w0.089: U21.Y3 104.4,88.91 104.48,88.83 104.74,88.83 104.85,88.94 105.2,88.94 105.4,88.74
  BOTTOM w0.102: 105.4,88.74 106.51,88.74 106.88,88.37 106.88,88.06 v1(106.69,87.87)
SATA_TXP0_C: length 1.9
  TOP w0.127: U12.1 203,38.8 202.96,38.76 202.09,38.76 C183.2
SATA_TXP0_CN: length 36.5
  TOP w0.127: C181.1 v1(208.49,40.14)
  IN3 w0.127: v1(208.49,40.14) 208.49,39.76 208.36,39.63 208.04,39.63 206.91,38.5 206.91,35.47 208.06,34.33 211.51,34.33 214.27,31.56 217.71,31.56 218.26,32.12 218.88,32.12 219.45,31.55 223.16,31.55 224.15,30.56 224.15,30.55 224.22,30.48 224.23,30.48 225.31,29.4 225.31,29.18 226.21,28.29 226.21,27.47 226.52,27.15 226.52,25.95 226.69,25.78 226.69,23.6 227.01,23.28 227.55,23.28 v1(227.72,23.1)
  BOTTOM w0.127: CN12.19 227.37,23.45 v1(227.72,23.1)
SATA_TXP0_M2: length 30.1
  TOP w0.127: v1(211.62,39.68) 211.11,39.68 210.92,39.87 R175.2
  IN3 w0.127: v1(229.7,26.48) 229.56,26.62 229.24,26.62 227.74,28.12 227.74,28.94 227.11,29.57 227.11,30.62 224.65,33.08 220.08,33.08 219.46,33.69 214.3,33.69 210.37,37.62 210.37,39.07 210.83,39.53 211.47,39.53 v1(211.62,39.68)
  BOTTOM w0.127: v1(229.7,26.48) 229.67,26.45 CN11.9
SATA_TXP0_RD: length 3.6
  TOP w0.127: U12.15 207.9,38.8 208.48,39.39 209.95,39.39 210.14,39.59 R175.1
SATA_TXP1: length 71.3
  IN1 w0.102: v1(105.66,89.85) 106.01,89.85 106.08,89.93 106.08,90.36 105.69,90.76 98.58,90.76 97.46,91.87 97.46,92.69 97.06,93.09 97.06,94.37 94.59,96.84 93.99,96.84 93.53,97.3 89.56,97.3 88.94,97.92 77.86,97.92 77.56,98.22 75.86,98.22 75.65,98.01 70.93,98.01 68.51,100.44 63.35,100.44 62.05,101.73 54.52,101.73 49.81,97.03 49.04,97.03 48.62,96.61 48.62,96.01 48.7,95.93 v1(49.3,95.93)
  BOTTOM w0.089: 105.55,89.42 105.51,89.42 105.44,89.49 105.11,89.49 U21.W1
  BOTTOM w0.102: 105.55,89.42 105.95,89.42 106.09,89.56 106.09,89.78 106.02,89.85 v1(105.66,89.85)
  BOTTOM w0.127: v1(49.3,95.93) 49.55,95.93 49.78,96.16 49.78,96.57 49.59,96.76 C326.2
SATA_TXP1_C: length 26.8
  BOTTOM w0.127: C324.1 48.85,97.07 48.85,95.69 49.03,95.51 49.03,95 v1(49.39,94.64) 49.03,94.28 49.03,93.76 48.3,93.03 31.93,93.03 29.18,95.78 CN5.49
SB_ACDC: length 204.2
  TOP w0.14: R88.1 69.06,82 v1(68.43,82.62) ; v1(45.92,45.3) 45.92,41.73 45.27,41.09 45.27,35.01 40.99,30.72 40.07,30.72 37.66,28.32 37.66,27.15 38.07,26.75 PR57.1 ; U16.84 149.03,25.66 150.87,27.5 150.87,27.95 150.53,28.29 150.53,30.5 147.69,33.34 147.69,34.43 v1(146.74,35.38)
  IN3 w0.127: v1(146.74,35.38) 146.24,35.88 143.19,35.88 142.48,36.58 142.09,36.58 141.46,35.96 138.42,35.96 137.58,36.8 133.28,36.8 132.07,38 130.87,38 130.54,38.33 127.32,38.33 124.85,40.8 119.86,40.8 117.48,38.43 117.48,36.86 115.55,34.93 113.49,34.93 113.35,35.08 109.05,35.08 107.26,33.28 104.48,33.28 103.63,34.14 98.09,34.14 97.07,33.12 54.49,33.12 47.3,40.31 47.3,43.92 v1(45.92,45.3) 45.92,46.28 45.15,47.05 45.15,62.01 45.58,62.44 45.58,64.87 63.33,82.62 v1(68.43,82.62)
SD_CLK_R: length 3.5
  TOP w0.127: R247.1 17.63,24.66 v1(17.21,24.24) 15.97,23 CN2.5
SENSEA: length 4.1
  TOP w0.102: v1(201,21.09) 200.95,21.09 200.23,21.81 R257.1
  TOP w0.203: U15.13 199.69,22.88
  TOP w0.254: 199.69,22.88 199.69,22.49 199.12,21.93 R256.1 R257.1
SIO_EXT_SCI#: length 124.4
  TOP w0.127: v1(127.13,41.38) 127.59,41.84 128.63,41.84 130.35,40.12 131.01,40.12 131.28,39.85 131.28,38.45 130.7,37.87 130.7,35.66 131.33,35.03 131.33,34.63 131.36,34.59 131.36,33.76 131.58,33.54 131.58,32.43 v1(132.2,31.81) 132.52,31.49 132.52,31.26 135.33,28.45 135.33,26.05 135.48,25.9 135.48,24 134.37,22.88 133.66,22.88 132.43,21.66 U16.23
  IN1 w0.102: v1(95.44,105.56) 97.15,103.85 101.68,103.85 104.14,101.38 108.03,101.38 109.29,100.11 111.06,100.11 116.01,95.17 116.01,88.56 123.31,81.25 123.31,68.65 125.3,66.67 125.3,50.08 124.26,49.04 124.26,44.25 v1(127.13,41.38)
  BOTTOM w0.102: U21.C34 89.27,97.67 89.55,97.95 89.55,99.42 90.42,100.29 91.05,100.29 91.45,100.7 92.12,100.7 92.32,100.9 92.71,100.9 92.83,101.02 92.83,101.54 93.03,101.75 93.03,102.72 93.29,102.98
  BOTTOM w0.127: R308.2 93.39,103.08 93.29,102.98
  BOTTOM w0.14: R308.2 93.9,103.85 93.9,104.37 95.09,105.56 v1(95.44,105.56)
SLEEVE: length 1.8
  TOP w0.203: v1(201.87,21.8) v1(201.87,22.43) 201.69,22.61 U15.18
  vias: v1(211.54,19.23) v1(211.7,19.92) v1(212.2,19.23)
SLP_S0IX#: length 3.7
  TOP w0.14: U16.117 137.48,32.86 137.35,32.99 137.35,34.83 136.88,35.31 TP15.1
SOC_OVRIDE: length 28.9
  BOTTOM w0.102: 70.32,98.07 73.16,98.07 75.16,96.08 75.65,96.08 U21.F62
  BOTTOM w0.14: 70.32,98.07 68.49,98.07 68.26,97.85 67.39,97.85 66.95,98.28 66.08,98.28 64.52,96.73 63.74,96.73 v1(62.89,95.88) 62.09,95.08 62.09,94.32 61.5,93.73 61.5,92.58 56.63,87.71 56.21,87.71 R381.2 55.44,88.48 Q30.3
SOC_SERIRQ: length 219.1
  TOP w0.127: U14.27 158.72,37.43 157.28,38.88 v1(156.86,38.88) 156.6,38.88 150.96,44.52 v1(149.92,44.52)
  IN1 w0.102: v1(45.81,29.52) 56.29,29.52 68.7,17.11 83,17.11 83.8,17.9 114.68,17.9 117.11,20.34 117.11,22.44 121.4,26.73 121.86,26.73 122.52,27.39 130,27.39 131.69,25.7 137.21,25.7 137.55,26.04 144.93,26.04 147.5,28.61 147.5,30.79 148.15,31.44 148.15,38.64 149.18,39.68 149.18,42.47 149.45,42.73 149.45,44.05 v1(149.92,44.52)
  BOTTOM w0.127: v1(45.81,29.52) 45.81,32.3 41.27,36.84 41.27,67.15 46.9,72.78 50.51,72.78 53.5,75.77 56.48,75.77 58.99,78.28 58.99,81.85 57.77,83.06 57.77,85.12 58.48,85.83 59.53,85.83 R386.2 61.56,86.39 62.32,85.63 62.32,85.4 62.17,85.25 U22.4
SOC_SERIRQ_R: length 18.4
  BOTTOM w0.089: U21.AB62 75.61,88.02 75.22,88.02 75.12,87.91 74.23,87.91 74.1,88.04
  BOTTOM w0.127: R386.1 59.84,86.92 v1(62.34,86.92) 64.07,86.92 64.88,86.11 67.4,86.11 68.87,87.58 70.22,87.58 70.71,87.09 72.23,87.09 73.18,88.04 74.1,88.04
SP1=SD_D1: length 30
  TOP w0.127: v1(17.62,30.26) C232.1 CN2.8 ; v1(26.53,31.52) 26.38,31.67 U13.14
  BOTTOM w0.127: v1(17.62,30.26) 15.09,30.26 14.92,30.44 14.92,31.66 15.05,31.79 15.3,31.79 15.43,31.66 15.43,30.9 15.56,30.77 15.81,30.77 15.94,30.9 15.94,31.66 16.06,31.79 16.32,31.79 16.44,31.66 16.44,30.9 16.57,30.77 16.83,30.77 16.95,30.9 16.95,31.66 17.08,31.79 17.33,31.79 17.46,31.66 17.46,30.9 17.59,30.77 17.84,30.77 17.97,30.9 17.97,31.66 18.1,31.79 18.6,31.79 18.73,31.66 18.73,30.39 18.86,30.26 19.11,30.26 19.24,30.39 19.24,31.66 19.37,31.79 19.62,31.79 19.75,31.66 19.75,30.39 19.87,30.26 20.13,30.26 20.25,30.39 20.25,30.78 20.38,30.91 20.64,30.91 20.76,30.78 20.76,30.39 20.89,30.26 23.99,30.26 25.25,31.52 v1(26.53,31.52)
SP2=SD_D0=MS_D1: length 29.8
  TOP w0.127: U13.15 26.78,31.92 27.11,31.59 27.11,31.37 v1(26.59,30.85) ; CN2.7 16.16,28.38 16.74,28.38 17.19,27.92 C238.1 v1(17.62,28.58)
  BOTTOM w0.127: v1(26.59,30.85) 26.01,30.85 25.83,30.85 25.68,31.01 25.5,31.01 25.32,30.83 25.32,30.65 25.47,30.49 25.47,30.31 25.29,30.13 25.11,30.13 24.94,30.31 24.76,30.31 24.58,30.13 24.58,29.95 24.75,29.77 24.75,29.6 24.57,29.42 24.4,29.42 24.28,29.53 24.1,29.53 23.92,29.35 23.92,29.17 24.04,29.06 24.04,28.88 23.73,28.58 23.54,28.58 23.41,28.7 23.41,29.63 23.29,29.76 23.03,29.76 22.91,29.63 22.91,28.7 22.78,28.58 22.52,28.58 22.4,28.7 22.4,29.63 22.27,29.76 22.02,29.76 21.89,29.63 21.89,28.7 21.76,28.58 21.51,28.58 21.38,28.7 21.38,29.63 21.25,29.76 21,29.76 20.87,29.63 20.87,28.7 20.75,28.58 20.49,28.58 20.37,28.7 20.37,29.63 20.24,29.76 19.98,29.76 19.86,29.63 19.86,28.7 19.73,28.58 19.48,28.58 19.35,28.7 19.35,29.05 19.22,29.18 18.7,29.18 18.45,29.43 16,29.43 15.76,29.19 15.76,28.75 15.94,28.58 v1(17.62,28.58)
SP3=SD_CLK=MS_D0: length 27.2
  TOP w0.127: v1(18.41,27.1) C246.1 R247.2 ; U13.16 27.18,31.92 27.34,31.76 27.34,30.84 26.33,29.84 26.33,29.56 v1(26.01,29.24)
  BOTTOM w0.127: v1(18.41,27.1) 18.88,27.1 19.09,26.88 19.09,26.09 19.22,25.97 19.48,25.97 19.6,26.09 19.6,27.03 19.75,27.18 20,27.18 20.11,27.07 20.11,26.09 20.24,25.97 20.49,25.97 20.62,26.09 20.62,27.03 20.73,27.15 20.99,27.15 21.13,27.01 21.13,26.09 21.25,25.97 21.51,25.97 21.63,26.09 21.63,27.22 21.76,27.35 22.02,27.35 22.14,27.22 22.14,26.09 22.27,25.97 22.52,25.97 22.65,26.09 22.65,27.22 22.78,27.35 23.03,27.35 23.16,27.22 23.16,26.09 23.29,25.97 23.54,25.97 23.67,26.09 23.67,27.22 23.79,27.35 24.09,27.35 24.32,27.12 24.32,26.56 24.44,26.44 24.95,26.44 25.36,26.84 25.36,28.58 25.64,28.86 v1(26.01,29.24)
SP4=SD_CMD=MS_D2: length 29.9
  TOP w0.127: CN2.2 v1(14.7,15.5) ; v1(27.01,27.59) 27.01,28.21 27.4,28.61 27.4,30.58 27.58,30.76 U13.17
  BOTTOM w0.127: v1(14.7,15.5) 14.06,15.5 13.85,15.29 13.85,14.98 14.22,14.61 14.22,13.9 C445.1 15.15,13.73 15.35,13.93 15.35,17.23 18.77,20.65 21.5,20.65 27.01,26.16 v1(27.01,27.59)
